HEC-RAS study HONEY CREEK.prj: HONEY CREEK Base Level Engineering

--- HONEY CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,56000,495,495,495
BEGIN DESCRIPTION:
HONEY CREEK 103.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2836455.69     10203353.11      2836584.00     10203194.00
      2836805.67     10202853.14
#Sta/Elev= 30
  4795.6 1357.37  4802.8 1357.90  4809.2 1356.54  4862.3 1352.79  4924.1 1349.24
  4937.2 1347.43  4965.9 1345.48  4973.9 1336.81  4990.1 1332.71  4990.6 1332.21
  5004.7 1332.71  5009.6 1333.78  5030.7 1334.47  5045.9 1336.80  5060.7 1337.83
  5067.0 1340.01  5072.9 1339.61  5082.1 1341.47  5088.1 1340.90  5103.2 1341.90
  5124.3 1340.89  5175.7 1341.88  5290.4 1347.94  5311.5 1351.53  5320.6 1352.28
  5335.1 1355.71  5343.5 1358.60  5362.8 1364.68  5383.9 1369.75  5406.6 1373.69
#Mann=5,-1,0
  4795.6    0.12       0  4862.3    0.05       0  4990.1    0.03       0
  5004.7    0.05       0  5343.5    0.12       0
Bank Sta=4990.1,5004.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,55505,497,497,497
BEGIN DESCRIPTION:
HONEY CREEK 102.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2836655.69     10203903.10      2837065.25     10203297.00
      2837155.67     10203103.15
#Sta/Elev= 30
  4268.5 1396.02  4271.5 1396.02  4276.0 1393.34  4282.0 1393.49  4290.9 1391.10
  4297.0 1391.60  4311.9 1387.68  4332.9 1385.33  4353.9 1381.18  4578.6 1355.67
  4686.5 1348.12  4823.7 1343.10  4851.3 1340.85  4866.4 1339.31  4872.4 1340.20
  4881.3 1338.08  4902.3 1337.93  4923.3 1335.75  4944.3 1331.28  4959.3 1332.32
  4987.9 1330.13  4988.4 1329.63  5002.6 1330.13  5085.4 1332.03  5108.3 1334.15
  5131.2 1340.54  5147.7 1348.96  5159.5 1358.21  5199.8 1367.60  5213.9 1368.64
#Mann=4,-1,0
  4268.5    0.05       0  4851.3    0.12       0  4987.9    0.07       0
  5002.6    0.12       0
Bank Sta=4987.9,5002.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,55008,156,156,156
BEGIN DESCRIPTION:
HONEY CREEK 101.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2836905.66     10204053.13      2837527.75     10203472.00
      2837355.70     10202903.15
#Sta/Elev= 30
  4148.7 1409.25  4219.3 1391.03  4240.8 1387.61  4276.0 1378.85  4297.5 1376.97
  4354.0 1367.18  4417.7 1360.30  4438.7 1356.57  4537.8 1349.43  4856.3 1331.23
  4913.0 1327.45  4934.0 1323.96  4962.4 1325.63  4983.5 1324.54  4988.1 1322.39
  4988.6 1321.89  5002.9 1322.39  5030.1 1322.75  5057.6 1329.57  5062.8 1328.46
  5082.4 1332.65  5199.8 1340.03  5227.6 1344.05  5260.0 1343.60  5336.8 1348.28
  5374.4 1353.45  5468.6 1362.12  5500.3 1366.67  5506.8 1368.96  5594.3 1378.19
#Mann=5,-1,0
  4148.7    0.05       0  4988.1    0.03       0  5002.9    0.05       0
  5030.1    0.12       0  5374.4    0.05       0
Bank Sta=4988.1,5002.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,54852,422,422,422
BEGIN DESCRIPTION:
Mapping XS 50091880
END DESCRIPTION:
XS GIS Cut Line= 4
      2837459.82     10204066.99      2837628.21     10203621.98
      2837766.53     10203315.26      2837760.57     10203136.53
#Sta/Elev= 30
  4453.5 1361.07  4478.9 1357.42  4484.3 1357.59  4489.7 1355.91  4509.1 1353.32
  4544.6 1349.84  4624.4 1343.90  4629.8 1342.85  4842.6 1330.19  4863.9 1328.07
  4904.7 1326.88  4917.4 1326.21  4926.0 1324.90  4957.6 1323.66  4971.9 1322.38
  4980.7 1322.58  4986.2 1321.86  4986.5 1320.02  4987.0 1319.52  5001.3 1320.02
  5009.3 1320.24  5032.5 1323.19  5055.6 1330.77  5084.2 1331.90  5101.8 1333.79
  5251.6 1339.96  5358.0 1345.90  5388.0 1347.88  5408.0 1350.08  5444.6 1352.11
#Mann=3,-1,0
  4453.5    0.05       0  4986.5    0.05       0  5001.3    0.05       0
Bank Sta=4986.5,5001.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,54430,376,376,376
BEGIN DESCRIPTION:
Mapping XS 2f0f259a
END DESCRIPTION:
XS GIS Cut Line= 4
      2837916.88     10204313.59      2837964.99     10203898.62
      2838055.20     10203646.03      2838181.10     10203130.44
#Sta/Elev= 30
  4448.2 1353.44  4509.1 1353.50  4549.3 1352.10  4566.3 1352.42  4571.3 1353.72
  4599.7 1352.29  4609.8 1352.88  4650.0 1349.51  4710.4 1346.36  4827.4 1334.06
  4832.4 1334.47  4865.9 1331.24  4880.0 1328.17  4885.3 1328.52  4910.8 1324.82
  4924.9 1325.09  4978.0 1320.03  4995.8 1316.67  4996.3 1316.17  5010.6 1316.67
  5041.7 1320.66  5073.5 1320.57  5116.7 1323.20  5417.5 1333.41  5456.9 1334.68
  5493.4 1337.32  5498.6 1336.45  5535.1 1341.47  5651.9 1350.37  5664.9 1350.19
#Mann=5,-1,0
  4448.2    0.05       0  4995.8    0.05       0  5010.6    0.05       0
  5116.7    0.12       0  5417.5    0.05       0
Bank Sta=4995.8,5010.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,54054,497,497,497
BEGIN DESCRIPTION:
HONEY CREEK 99.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2838305.70     10203953.07      2838384.00     10203766.00
      2838855.70     10203153.10
#Sta/Elev= 30
  4797.2 1337.34  4864.8 1332.60  4883.1 1329.25  4888.6 1329.62  4912.3 1323.89
  4936.1 1320.86  4941.6 1321.61  4951.2 1319.64  4965.4 1316.55  4970.8 1318.46
  5046.5 1315.94  5047.0 1315.44  5061.4 1315.94  5117.2 1316.35  5153.6 1317.97
  5229.0 1317.21  5274.1 1317.32  5338.5 1319.79  5382.0 1322.87  5394.8 1324.76
  5452.6 1327.09  5502.5 1331.33  5552.3 1333.81  5587.6 1336.81  5622.9 1343.07
  5672.8 1347.54  5710.0 1353.39  5745.3 1356.67  5773.3 1360.60  5773.4 1360.60
#Mann=6,-1,0
  4797.2    0.05       0  4951.2    0.12       0  5046.5    0.07       0
  5061.4    0.12       0  5229.0    0.05       0  5773.3    0.12       0
Bank Sta=5046.5,5061.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,53557,500,500,500
BEGIN DESCRIPTION:
HONEY CREEK 98.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2838405.65     10204053.14      2838821.50     10203706.00
      2839405.69     10203103.11
#Sta/Elev= 30
  4458.3 1338.00  4671.1 1324.69  4898.9 1322.33  4905.4 1319.78  4948.4 1312.27
  4977.0 1312.21  5004.6 1307.67  5005.1 1307.17  5019.6 1307.67  5033.2 1309.35
  5040.4 1314.15  5047.3 1315.39  5054.5 1320.01  5068.7 1323.50  5118.1 1327.92
  5172.9 1329.65  5259.6 1334.21  5287.9 1339.24  5340.0 1345.11  5359.9 1346.55
  5379.9 1349.63  5457.6 1355.02  5507.0 1362.33  5563.6 1365.93  5620.4 1371.59
  5655.7 1380.38  5698.1 1396.42  5768.9 1419.54  5797.2 1430.31  5839.5 1442.52
#Mann=7,-1,0
  4458.3    0.05       0  5004.6    0.05       0  5019.6    0.05       0
  5172.9    0.05       0  5340.0    0.12       0  5359.9    0.05       0
  5620.4    0.12       0
Bank Sta=5004.6,5019.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,53057,473,473,473
BEGIN DESCRIPTION:
HONEY CREEK 97.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2838755.73     10204103.11      2839149.50     10204072.00
      2839705.69     10203453.10
#Sta/Elev= 30
  4605.0 1323.33  4705.3 1319.72  4769.7 1315.46  4805.6 1310.24  4825.6 1312.55
  4905.9 1314.13  4987.7 1303.17  4988.2 1302.67  5003.5 1303.17  5017.7 1303.29
  5038.8 1306.26  5052.8 1313.09  5145.5 1322.26  5159.7 1325.43  5230.0 1330.96
  5251.7 1334.69  5340.5 1338.09  5421.3 1337.50  5591.0 1341.85  5647.8 1347.00
  5665.4 1350.79  5690.4 1356.85  5711.4 1364.97  5718.8 1368.61  5733.0 1378.79
  5754.0 1385.99  5761.4 1390.42  5768.2 1391.42  5804.1 1404.76  5832.1 1411.34
#Mann=6,-1,0
  4605.0    0.05       0  4769.7    0.12       0  4987.7    0.07       0
  5003.5    0.12       0  5340.5    0.05       0  5665.4    0.12       0
Bank Sta=4987.7,5003.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,52584,378,378,378
BEGIN DESCRIPTION:
HONEY CREEK 96.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2839155.65     10204503.12      2839459.00     10204400.00
      2839505.67     10204203.16
#Sta/Elev= 30
  4679.6 1318.42  4752.8 1316.78  4789.5 1315.42  4820.8 1315.32  4827.5 1314.65
  4838.1 1314.62  4882.5 1311.62  4890.9 1310.82  4901.4 1308.65  4909.7 1306.00
  4915.0 1303.48  4922.6 1301.63  4941.1 1300.31  4954.2 1300.41  4964.8 1301.13
  4967.7 1300.95  4972.4 1300.66  4985.9 1298.77  5000.0 1298.32  5001.8 1297.78
  5002.3 1297.28  5017.2 1297.28  5017.7 1297.78  5027.6 1297.97  5046.8 1303.03
  5052.0 1307.09  5058.5 1310.03  5068.7 1311.97  5120.1 1315.19  5202.3 1318.89
#Mann=5,-1,0
  4679.6    0.05       0  4882.5    0.12       0  4967.7    0.05       0
  5001.8    0.05       0  5017.7    0.05       0
Bank Sta=5001.8,5017.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,52206,594,594,594
BEGIN DESCRIPTION:
Mapping XS d56716cb
END DESCRIPTION:
XS GIS Cut Line= 2
      2839523.74     10205034.12      2839923.07     10204339.64
#Sta/Elev= 30
  4528.9 1313.58  4684.5 1310.18  4749.2 1309.63  4786.6 1308.44  4844.2 1308.19
  4861.3 1308.27  4885.0 1306.49  4898.7 1304.95  4910.7 1301.91  4947.6 1296.42
  4956.9 1295.56  4969.1 1295.98  4992.7 1295.37  4993.2 1294.87  5008.2 1294.87
  5008.7 1295.37  5014.5 1295.51  5022.3 1297.04  5028.1 1299.26  5043.9 1308.42
  5049.6 1313.03  5058.4 1314.50  5087.0 1315.33  5102.8 1316.81  5108.6 1315.71
  5140.2 1315.35  5145.9 1314.73  5176.0 1314.98  5227.5 1314.35  5330.0 1314.86
#Mann=7,-1,0
  4528.9    0.05       0  4844.2    0.12       0  4885.0    0.05       0
  4992.7    0.05       0  5008.7    0.05       0  5058.4    0.12       0
  5227.5    0.05       0
Bank Sta=4992.7,5008.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,51612,430,430,430
BEGIN DESCRIPTION:
HONEY CREEK 94.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2839955.69     10205403.10      2840162.00     10205054.00
      2840105.68     10204603.10
#Sta/Elev= 30
  4594.5 1310.74  4611.2 1310.22  4702.3 1307.91  4768.7 1305.96  4777.9 1306.63
  4826.8 1303.97  4863.6 1301.49  4873.3 1299.85  4879.3 1297.54  4885.1 1299.70
  4894.9 1297.58  4900.7 1299.83  4916.4 1295.50  4922.2 1297.11  4931.3 1294.74
  4959.2 1293.30  4990.6 1289.82  4991.1 1289.32  5006.8 1289.82  5031.1 1290.55
  5041.2 1292.80  5088.9 1297.19  5101.7 1296.81  5142.0 1299.50  5192.4 1300.24
  5222.9 1302.84  5273.0 1306.43  5322.5 1307.12  5422.1 1309.38  5454.4 1310.88
#Mann=8,-1,0
  4594.5    0.05       0  4611.2    0.12       0  4702.3    0.05       0
  4990.6    0.05       0  5006.8    0.05       0  5222.9    0.12       0
  5322.5    0.05       0  5422.1    0.12       0
Bank Sta=4990.6,5006.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,51182,572,572,572
BEGIN DESCRIPTION:
Mapping XS 494f8079
END DESCRIPTION:
XS GIS Cut Line= 4
      2840593.08     10205480.29      2840593.08     10205131.48
      2840508.89     10204933.02      2840322.46     10204578.21
#Sta/Elev= 30
  4578.2 1303.60  4616.4 1301.48  4665.4 1300.22  4705.4 1296.77  4765.4 1296.37
  4775.4 1297.58  4793.3 1297.40  4855.4 1299.11  4895.4 1297.85  4927.0 1295.67
  4931.9 1294.57  4947.0 1293.38  4961.0 1288.38  5014.6 1286.82  5015.1 1286.32
  5031.5 1286.82  5066.5 1289.51  5077.3 1289.91  5090.2 1289.18  5110.1 1290.98
  5137.5 1293.24  5145.4 1293.03  5159.8 1294.06  5242.4 1295.10  5278.0 1296.69
  5323.2 1300.74  5345.8 1301.11  5413.1 1304.71  5467.0 1305.25  5543.4 1305.55
#Mann=7,-1,0
  4578.2    0.12       0  4616.4    0.05       0  4793.3    0.12       0
  5014.6    0.07       0  5031.5    0.05       0  5110.1    0.05       0
  5467.0    0.12       0
Bank Sta=5014.6,5031.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,50610,408,408,408
BEGIN DESCRIPTION:
Mapping XS 7c9acef9
END DESCRIPTION:
XS GIS Cut Line= 2
      2841259.86     10204964.67      2840634.89     10204322.34
#Sta/Elev= 30
  4610.3 1300.39  4642.6 1298.62  4713.3 1297.88  4734.6 1296.00  4755.7 1296.19
  4775.7 1295.22  4847.8 1291.73  4854.8 1292.28  4868.9 1292.20  4875.2 1291.60
  4892.3 1290.51  4911.4 1290.19  4932.7 1286.43  4967.9 1283.75  4975.1 1282.50
  4994.1 1280.90  4994.6 1280.40  5011.8 1280.40  5012.3 1280.90  5018.2 1281.28
  5025.3 1282.16  5052.8 1284.74  5067.0 1284.96  5102.2 1287.68  5144.7 1290.02
  5151.8 1289.55  5163.4 1290.39  5201.3 1291.62  5250.9 1291.75  5506.5 1296.32
#Mann=9,-1,0
  4610.3    0.05       0  4775.7    0.12       0  4875.2    0.05       0
  4892.3    0.12       0  4994.1    0.07       0  5012.3    0.12       0
  5018.2    0.05       0  5025.3    0.12       0  5163.4    0.05       0
Bank Sta=4994.1,5012.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,50202,464,464,464
BEGIN DESCRIPTION:
HONEY CREEK 91.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2841855.68     10204853.11      2841261.00     10204386.00
      2840905.71     10203803.15
#Sta/Elev= 30
  4243.8 1347.96  4294.4 1342.07  4315.2 1338.02  4371.3 1330.02  4443.5 1317.16
  4493.2 1310.50  4552.0 1305.74  4737.5 1294.05  4814.1 1289.79  4913.5 1282.08
  4934.3 1281.06  4963.2 1281.49  4980.4 1279.12  4984.0 1277.92  4989.1 1277.81
  4989.6 1277.31  5007.4 1277.81  5020.4 1278.60  5035.8 1281.61  5057.2 1281.25
  5148.6 1284.99  5202.5 1286.62  5326.3 1287.09  5378.2 1288.50  5399.9 1290.16
  5463.8 1296.29  5552.9 1308.41  5558.7 1308.18  5653.6 1323.71  5682.6 1326.54
#Mann=7,-1,0
  4243.8    0.05       0  4552.0    0.12       0  4737.5    0.05       0
  4980.4    0.12       0  4989.1    0.07       0  5007.4    0.12       0
  5148.6    0.05       0
Bank Sta=4989.1,5007.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,49738,460,460,460
BEGIN DESCRIPTION:
HONEY CREEK 90.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2841705.68     10204203.10      2841611.00     10204090.00
      2841305.65     10203803.08
#Sta/Elev= 30
  4852.5 1293.27  4855.8 1293.27  4890.8 1285.72  4902.6 1282.63  4909.1 1281.59
  4937.7 1280.65  4952.0 1279.13  4971.5 1274.09  4972.0 1273.59  4989.3 1273.59
  4989.8 1274.09  5008.5 1275.77  5015.8 1274.61  5022.6 1275.98  5036.8 1276.70
  5065.1 1277.06  5079.3 1276.17  5100.7 1277.94  5150.1 1279.07  5171.5 1280.56
  5223.6 1279.72  5312.7 1281.65  5341.1 1282.67  5362.5 1284.74  5369.4 1284.73
  5376.7 1285.58  5390.8 1288.56  5397.7 1291.12  5415.5 1294.41  5419.0 1294.41
#Mann=5,-1,0
  4852.5    0.05       0  4890.8    0.12       0  4971.5    0.07       0
  4989.8    0.12       0  5223.6    0.05       0
Bank Sta=4971.5,4989.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,49278,463,463,463
BEGIN DESCRIPTION:
HONEY CREEK 89.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2842105.66     10204003.07      2841936.00     10203768.00
      2841355.72     10203703.12
#Sta/Elev= 30
  4710.1 1302.35  4717.1 1301.67  4732.1 1299.07  4868.3 1282.43  4882.7 1281.56
  4896.6 1278.81  4903.9 1278.37  4939.5 1271.27  4959.7 1268.84  4960.2 1268.34
  4978.0 1268.84  5020.4 1269.60  5050.6 1271.95  5070.8 1271.92  5092.4 1269.94
  5111.0 1274.48  5261.9 1276.12  5342.4 1275.11  5358.2 1275.53  5367.7 1277.65
  5382.7 1280.97  5402.8 1279.85  5412.9 1280.71  5448.5 1285.13  5453.6 1287.33
  5463.2 1288.84  5503.4 1291.21  5533.6 1293.92  5538.8 1295.46  5583.9 1299.28
#Mann=6,-1,0
  4710.1    0.12       0  4717.1    0.05       0  4896.6    0.12       0
  4959.7    0.07       0  4978.0    0.12       0  5367.7    0.05       0
Bank Sta=4959.7,4978
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,48815,469,469,469
BEGIN DESCRIPTION:
HONEY CREEK 88.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2842355.70     10203753.15      2842270.50     10203458.00
      2842005.69     10202853.13
#Sta/Elev= 30
  4692.8 1296.73  4697.5 1296.46  4743.3 1290.06  4796.9 1275.56  4820.6 1274.69
  4942.6 1267.84  4989.8 1259.57  4990.3 1259.07  5009.4 1259.57  5016.3 1259.63
  5028.6 1265.61  5038.1 1266.69  5092.7 1267.10  5118.0 1269.48  5320.1 1278.22
  5397.2 1289.00  5442.0 1295.26  5500.1 1308.33  5518.1 1314.51  5523.5 1313.74
  5546.9 1323.60  5552.4 1323.18  5575.7 1329.98  5599.1 1337.36  5605.7 1341.08
  5616.7 1343.41  5622.5 1347.00  5638.5 1350.89  5645.9 1354.83  5660.3 1358.14
#Mann=7,-1,0
  4692.8    0.12       0  4697.5    0.05       0  4820.6    0.12       0
  4989.8    0.07       0  5009.4    0.12       0  5118.0    0.05       0
  5397.2    0.12       0
Bank Sta=4989.8,5009.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,48346,489,489,489
BEGIN DESCRIPTION:
HONEY CREEK 87.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2842955.67     10203353.10      2842676.75     10203227.00
      2842355.65     10202903.08
#Sta/Elev= 30
  4693.9 1296.50  4708.2 1294.01  4715.8 1291.73  4737.8 1288.28  4768.0 1285.97
  4823.7 1277.64  4829.2 1275.38  4846.8 1272.05  4858.7 1268.73  4875.4 1262.95
  4904.0 1261.32  4935.3 1261.93  4973.4 1257.85  5000.8 1257.34  5001.3 1256.84
  5020.4 1257.34  5031.8 1260.65  5046.0 1263.14  5079.7 1263.97  5097.1 1265.18
  5194.4 1267.44  5230.5 1269.24  5279.3 1271.81  5300.5 1273.52  5314.7 1275.86
  5335.8 1276.67  5368.7 1280.36  5420.7 1288.57  5452.5 1296.68  5456.1 1296.68
#Mann=9,-1,0
  4693.9    0.12       0  4768.0    0.05       0  4858.7    0.12       0
  5000.8    0.07       0  5020.4    0.12       0  5079.7    0.05       0
  5097.1    0.12       0  5230.5    0.05       0  5368.7    0.12       0
Bank Sta=5000.8,5020.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,47857,436,436,436
BEGIN DESCRIPTION:
HONEY CREEK 86.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2843255.66     10203253.07      2843135.50     10203067.00
      2842555.68     10202503.11
#Sta/Elev= 30
  4778.5 1310.93  4807.2 1308.14  4822.3 1304.62  4843.5 1302.13  4858.6 1296.65
  4873.7 1293.73  4879.7 1290.97  4903.1 1286.43  4937.2 1278.37  4952.3 1273.49
  4967.5 1254.16  4984.8 1250.44  4985.3 1249.94  5004.4 1250.44  5023.9 1253.23
  5030.9 1257.25  5045.0 1260.20  5080.5 1261.19  5101.6 1263.23  5179.5 1261.50
  5200.6 1259.49  5236.1 1259.66  5264.4 1257.41  5299.6 1263.62  5459.0 1273.23
  5490.5 1275.18  5511.8 1278.40  5702.7 1296.64  5787.6 1306.55  5808.8 1311.56
#Mann=5,-1,0
  4778.5    0.12       0  4903.1    0.05       0  4984.8    0.05       0
  5004.4    0.05       0  5459.0    0.12       0
Bank Sta=4984.8,5004.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,47421,833,833,833
BEGIN DESCRIPTION:
HONEY CREEK 85.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2843505.70     10202953.14      2843433.00     10202765.00
      2843305.68     10202153.11
#Sta/Elev= 30
  4798.3 1284.36  4884.1 1267.84  4905.5 1258.53  4916.3 1259.90  4927.8 1255.07
  4959.1 1246.55  4988.5 1245.91  4989.0 1245.41  5008.2 1245.91  5014.3 1249.59
  5033.2 1251.92  5047.1 1252.25  5064.4 1254.88  5165.4 1258.24  5196.0 1257.93
  5226.6 1251.57  5247.1 1251.42  5304.6 1254.57  5404.7 1263.32  5430.9 1266.72
  5449.7 1271.70  5454.8 1270.44  5461.6 1274.43  5499.8 1282.93  5504.9 1282.36
  5543.3 1291.06  5584.1 1297.61  5600.0 1302.93  5605.1 1302.29  5625.0 1306.27
#Mann=5,-1,0
  4798.3    0.12       0  4988.5    0.07       0  5008.2    0.12       0
  5033.2    0.05       0  5047.1    0.12       0
Bank Sta=4988.5,5008.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,46588,566,566,566
BEGIN DESCRIPTION:
HONEY CREEK 83.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2843955.69     10202653.09      2844067.25     10202380.00
      2844005.68     10201853.08
#Sta/Elev= 30
  4705.0 1261.61  4773.1 1256.49  4797.2 1253.25  4875.3 1250.38  4957.5 1244.33
  4975.0 1239.07  4997.0 1237.79  4997.5 1237.29  5016.8 1237.79  5027.1 1241.77
  5037.1 1248.39  5047.2 1257.84  5054.4 1260.61  5059.4 1260.08  5077.4 1265.29
  5142.8 1276.38  5147.9 1278.45  5208.3 1290.83  5231.2 1297.77  5238.5 1301.42
  5258.6 1304.39  5278.8 1309.38  5309.0 1319.52  5314.5 1323.12  5319.6 1323.39
  5349.2 1332.94  5359.3 1337.74  5446.6 1361.76  5486.3 1374.53  5530.5 1386.60
#Mann=5,-1,0
  4705.0    0.05       0  4875.3    0.12       0  4997.0    0.07       0
  5016.8    0.12       0  5446.6    0.05       0
Bank Sta=4997,5016.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,46022,479,479,479
BEGIN DESCRIPTION:
HONEY CREEK 82.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2844855.68     10203353.10      2844610.75     10202538.00
      2844205.71     10201753.15
#Sta/Elev= 30
  4148.9 1364.04  4269.7 1331.66  4316.0 1321.62  4347.3 1317.81  4379.3 1309.38
  4535.2 1283.77  4628.4 1272.04  4656.7 1268.79  4681.4 1266.99  4720.1 1259.98
  4824.4 1247.29  4895.7 1241.92  5028.6 1235.90  5029.1 1235.40  5048.7 1235.90
  5060.8 1239.57  5105.2 1244.99  5191.9 1251.02  5305.0 1259.29  5388.8 1267.20
  5437.5 1272.10  5531.2 1288.39  5587.5 1300.44  5634.0 1312.55  5703.4 1331.26
  5736.4 1336.59  5764.2 1344.59  5847.2 1359.73  5852.8 1363.09  5883.2 1368.78
#Mann=11,-1,0
  4148.9    0.05       0  4628.4    0.12       0  4656.7    0.05       0
  5028.6    0.05       0  5048.7    0.05       0  5191.9    0.12       0
  5305.0    0.05       0  5388.8    0.12       0  5531.2    0.05       0
  5587.5    0.12       0  5634.0    0.05       0
Bank Sta=5028.6,5048.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,45543,489,489,489
BEGIN DESCRIPTION:
HONEY CREEK 81.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2845105.68     10203453.08      2845079.50     10202630.00
      2845605.68     10201853.12
#Sta/Elev= 30
  4176.5 1395.90  4226.5 1377.78  4296.5 1361.51  4332.6 1350.12  4337.6 1350.57
  4386.6 1337.62  4496.6 1315.33  4546.7 1299.86  4668.4 1277.50  4845.3 1253.30
  4946.9 1235.89  5032.1 1235.44  5034.5 1233.94  5035.0 1233.44  5054.7 1233.94
  5089.0 1238.00  5167.0 1239.40  5203.0 1242.16  5219.3 1242.66  5319.7 1248.74
  5427.5 1258.42  5484.5 1259.59  5541.4 1268.78  5567.1 1275.37  5636.4 1293.40
  5679.2 1310.86  5757.1 1337.16  5823.0 1353.30  5873.9 1370.53  5938.3 1389.27
#Mann=8,-1,0
  4176.5    0.05       0  4668.4    0.12       0  4845.3    0.05       0
  5034.5    0.05       0  5054.7    0.05       0  5203.0    0.12       0
  5219.3    0.05       0  5567.1    0.12       0
Bank Sta=5034.5,5054.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,45054,565,565,565
BEGIN DESCRIPTION:
HONEY CREEK 80.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2845505.68     10203353.14      2845561.00     10202574.00
      2845705.69     10201853.08
#Sta/Elev= 30
  4218.9 1366.65  4249.0 1354.20  4299.1 1340.51  4427.6 1312.12  4432.6 1313.23
  4449.5 1306.84  4519.7 1290.83  4596.2 1278.36  4750.3 1259.27  4867.4 1246.96
  4920.7 1240.42  4960.8 1231.02  5001.0 1227.74  5001.5 1227.24  5021.2 1227.74
  5064.6 1230.66  5110.0 1233.73  5200.7 1247.89  5245.7 1252.19  5276.3 1259.09
  5319.8 1272.02  5347.7 1279.93  5404.4 1302.95  5439.5 1310.97  5460.4 1319.15
  5506.2 1333.06  5551.7 1344.42  5623.1 1369.63  5658.9 1380.06  5735.3 1396.06
#Mann=8,-1,0
  4218.9    0.05       0  4596.2    0.12       0  4867.4    0.05       0
  5001.0    0.05       0  5021.2    0.05       0  5064.6    0.12       0
  5110.0    0.05       0  5319.8    0.12       0
Bank Sta=5001,5021.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,44489,590,590,590
BEGIN DESCRIPTION:
HONEY CREEK 79.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2846705.66     10203253.07      2846108.00     10202440.00
      2846005.69     10202003.12
#Sta/Elev= 30
  3990.9 1409.88  4040.5 1399.83  4054.5 1392.87  4067.3 1389.94  4127.4 1375.29
  4148.6 1364.34  4169.5 1358.59  4184.1 1350.00  4219.6 1338.63  4234.3 1329.61
  4250.4 1323.70  4334.6 1293.33  4355.4 1289.38  4370.1 1280.28  4470.4 1254.73
  4509.2 1248.75  4530.0 1245.78  4685.6 1236.35  4777.5 1234.56  4892.4 1224.51
  4932.4 1223.59  4932.9 1223.09  4952.7 1223.59  5007.1 1225.12  5028.2 1228.89
  5032.4 1229.12  5074.9 1258.00  5202.2 1285.49  5340.0 1322.27  5448.7 1356.80
#Mann=8,-1,0
  3990.9    0.05       0  4067.3    0.12       0  4250.4    0.05       0
  4509.2    0.12       0  4530.0    0.05       0  4932.4    0.05       0
  4952.7    0.05       0  5028.2    0.12       0
Bank Sta=4932.4,4952.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,43899,591,591,591
BEGIN DESCRIPTION:
HONEY CREEK 78.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2846905.68     10203103.10      2846676.75     10202574.00
      2846105.68     10201753.10
#Sta/Elev= 30
  4423.5 1399.25  4478.0 1381.59  4511.6 1367.59  4537.3 1358.34  4543.3 1352.31
  4560.8 1344.70  4613.3 1325.46  4660.2 1296.64  4689.2 1284.14  4712.7 1270.29
  4724.6 1266.41  4753.1 1254.53  4788.6 1240.51  4835.5 1228.19  4908.7 1221.48
  4987.6 1216.69  4988.1 1216.19  5008.0 1216.69  5050.8 1217.73  5059.5 1221.87
  5065.6 1220.38  5080.5 1225.89  5166.9 1235.58  5447.1 1260.06  5549.2 1279.60
  5626.0 1297.57  5784.0 1345.24  5878.2 1366.03  5891.3 1371.08  6000.0 1393.71
#Mann=8,-1,0
  4423.5    0.05       0  4511.6    0.12       0  4724.6    0.05       0
  4753.1    0.12       0  4908.7    0.05       0  4987.6    0.03       0
  5008.0    0.05       0  5549.2    0.12       0
Bank Sta=4987.6,5008
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,43308,598,598,598
BEGIN DESCRIPTION:
HONEY CREEK 77.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2847355.69     10202903.14      2847226.75     10202515.00
      2846405.68     10201753.11
#Sta/Elev= 30
  4591.0 1367.19  4664.8 1352.11  4718.8 1336.56  4765.2 1324.32  4791.2 1319.74
  4796.9 1316.22  4828.5 1305.81  4844.9 1302.45  4886.1 1289.22  4917.7 1258.85
  4923.5 1256.49  4949.3 1228.40  4960.5 1214.22  4970.4 1209.40  4988.2 1206.54
  4988.7 1206.04  5008.6 1206.54  5030.2 1208.45  5108.4 1221.38  5136.7 1223.41
  5391.3 1229.65  5462.2 1235.06  5645.9 1244.22  5730.9 1251.51  5780.2 1257.19
  5836.9 1266.87  5922.0 1285.34  5957.8 1295.45  6112.0 1337.04  6120.1 1339.40
#Mann=7,-1,0
  4591.0    0.05       0  4718.8    0.12       0  4844.9    0.05       0
  4988.2    0.03       0  5008.6    0.05       0  5957.8    0.12       0
  6112.0    0.05       0
Bank Sta=4988.2,5008.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,42710,525,525,525
BEGIN DESCRIPTION:
HONEY CREEK 76.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2847605.70     10202403.15      2847444.25     10201980.00
      2846655.68     10201553.11
#Sta/Elev= 30
  4547.1 1270.93  4562.2 1269.69  4579.2 1265.52  4611.4 1262.24  4617.0 1260.01
  4646.5 1255.77  4671.8 1250.09  4732.0 1241.74  4844.1 1222.43  4857.5 1220.95
  4878.9 1214.10  4911.0 1206.84  5010.0 1205.69  5010.5 1205.19  5030.4 1205.69
  5032.5 1208.54  5085.8 1212.75  5248.5 1217.72  5364.5 1223.50  5446.3 1228.03
  5615.6 1240.91  5713.6 1253.47  5801.1 1272.48  5806.8 1272.03  5823.0 1276.31
  5844.9 1279.23  5851.2 1282.37  5888.6 1290.67  5893.9 1293.96  5896.7 1293.96
#Mann=5,-1,0
  4547.1    0.05       0  4646.5    0.12       0  4844.1    0.05       0
  5010.0    0.05       0  5030.4    0.05       0
Bank Sta=5010,5030.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,42185,530,530,530
BEGIN DESCRIPTION:
HONEY CREEK 75.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2848455.67     10202303.09      2847713.75     10201535.00
      2847605.69     10200753.13
#Sta/Elev= 30
  3932.1 1285.53  4094.8 1267.96  4144.2 1258.19  4264.6 1240.90  4363.4 1231.30
  4639.4 1212.52  4660.5 1215.94  4688.8 1216.03  4893.8 1210.26  4968.4 1196.16
  4968.9 1195.66  4988.9 1196.16  4992.5 1196.75  5013.9 1197.22  5052.4 1199.68
  5072.6 1198.04  5113.7 1206.82  5163.4 1224.86  5173.5 1230.78  5312.2 1269.37
  5335.0 1270.30  5389.1 1281.56  5460.9 1299.55  5486.5 1309.84  5526.8 1316.41
  5532.8 1321.29  5537.8 1320.33  5587.4 1336.03  5637.9 1354.94  5789.3 1404.52
#Mann=6,-1,0
  3932.1    0.05       0  4968.4    0.07       0  4988.9    0.05       0
  4992.5    0.12       0  5013.9    0.05       0  5113.7    0.12       0
Bank Sta=4968.4,4988.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,41655,579,579,579
BEGIN DESCRIPTION:
HONEY CREEK 74.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2848505.67     10202153.09      2848161.00     10201415.00
      2847805.70     10200603.14
#Sta/Elev= 30
  4185.4 1276.93  4218.6 1273.07  4262.6 1266.90  4287.0 1261.53  4387.9 1250.92
  4479.3 1237.26  4560.6 1228.36  4878.9 1200.81  4934.5 1193.55  4980.4 1187.68
  4980.9 1187.18  5001.7 1187.68  5027.5 1189.02  5050.9 1195.12  5079.8 1214.28
  5111.2 1223.02  5290.9 1250.54  5376.8 1267.31  5394.7 1268.47  5406.1 1272.39
  5452.4 1284.69  5482.4 1295.55  5591.5 1326.55  5673.8 1360.19  5755.2 1389.19
  5809.8 1407.36  5825.0 1410.95  5842.6 1419.00  5848.4 1423.75  5886.2 1439.71
#Mann=8,-1,0
  4185.4    0.05       0  4218.6    0.12       0  4287.0    0.05       0
  4934.5    0.12       0  4980.4    0.07       0  5001.7    0.12       0
  5290.9    0.05       0  5406.1    0.12       0
Bank Sta=4980.4,5001.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,41076,1016,1016,1016
BEGIN DESCRIPTION:
HONEY CREEK 73.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2848705.68     10201603.11      2848656.00     10201177.00
      2848155.69     10200353.11
#Sta/Elev= 30
  4571.0 1231.65  4641.5 1234.90  4671.7 1232.41  4710.2 1225.71  4809.7 1213.64
  4903.2 1204.26  4931.5 1198.70  4953.6 1189.81  4959.1 1183.59  4973.1 1180.86
  4973.6 1180.36  4994.4 1180.86  5025.8 1180.99  5045.7 1184.00  5068.5 1188.22
  5120.8 1192.65  5184.8 1205.26  5237.1 1209.59  5316.5 1222.35  5353.4 1230.58
  5447.0 1258.36  5484.2 1271.65  5622.8 1335.74  5665.4 1349.76  5686.8 1359.84
  5694.8 1365.73  5723.6 1378.06  5760.4 1399.70  5818.5 1426.19  5963.9 1481.91
#Mann=8,-1,0
  4571.0    0.05       0  4710.2    0.12       0  4809.7    0.05       0
  4931.5    0.12       0  4973.1    0.07       0  4994.4    0.12       0
  5045.7    0.05       0  5447.0    0.12       0
Bank Sta=4973.1,4994.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,40060,1025,1025,1025
BEGIN DESCRIPTION:
HONEY CREEK 71.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2849455.68     10201353.07      2849448.50     10200583.00
      2849205.69     10200253.13
#Sta/Elev= 30
  4229.9 1216.27  4299.9 1212.50  4409.9 1203.76  4479.9 1195.58  4576.9 1188.71
  4691.8 1183.35  4838.3 1178.08  4841.8 1178.01  4889.9 1173.92  4909.9 1169.53
  4939.9 1170.23  4949.2 1168.77  4949.7 1168.27  4970.6 1168.77  4979.9 1170.99
  5045.1 1171.10  5059.8 1178.01  5066.0 1177.15  5080.6 1188.18  5101.5 1197.30
  5109.9 1203.52  5116.1 1206.12  5130.8 1219.81  5160.0 1235.37  5213.7 1249.28
  5281.2 1264.12  5316.7 1266.56  5331.3 1272.76  5394.9 1282.85  5409.6 1286.29
#Mann=9,-1,0
  4229.9    0.12       0  4576.9    0.05       0  4691.8    0.12       0
  4838.3    0.05       0  4841.8    0.12       0  4949.2    0.07       0
  4970.6    0.12       0  5213.7    0.05       0  5394.9    0.12       0
Bank Sta=4949.2,4970.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,39035,594,594,594
BEGIN DESCRIPTION:
HONEY CREEK 69.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2850155.66     10201103.15      2850408.00     10200780.00
      2850155.71     10200453.14
#Sta/Elev= 30
  4590.0 1186.13  4632.6 1184.99  4676.0 1180.66  4690.4 1180.24  4740.2 1173.16
  4754.6 1168.53  4761.0 1168.73  4767.7 1165.35  4775.5 1163.57  4846.0 1160.81
  4854.1 1158.95  4860.5 1159.55  4868.6 1157.73  4889.4 1155.36  4903.9 1154.59
  4910.2 1155.43  4939.2 1155.39  4949.2 1153.89  4949.7 1153.39  4970.7 1153.89
  5007.2 1156.84  5028.0 1156.29  5048.8 1158.94  5113.1 1162.71  5156.9 1168.94
  5235.4 1176.28  5299.2 1179.35  5349.6 1183.26  5403.9 1184.04  5412.9 1184.56
#Mann=5,-1,0
  4590.0    0.12       0  4949.2    0.07       0  4970.7    0.12       0
  5156.9    0.05       0  5403.9    0.12       0
Bank Sta=4949.2,4970.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,38441,595,595,595
BEGIN DESCRIPTION:
HONEY CREEK 68.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2850755.68     10201003.10      2850714.25     10200286.00
      2850305.67     10200253.11
#Sta/Elev= 30
  4281.7 1171.28  4372.6 1167.82  4420.0 1162.75  4502.1 1156.47  4544.4 1157.76
  4562.2 1156.56  4592.2 1158.44  4602.2 1156.42  4642.3 1153.76  4716.3 1155.65
  4752.5 1153.33  4792.5 1152.94  4802.6 1150.60  4913.4 1148.83  4944.1 1147.25
  4982.1 1145.88  4982.6 1145.38  5003.6 1145.88  5022.6 1147.51  5038.7 1151.41
  5088.9 1154.74  5101.1 1157.30  5176.6 1165.29  5218.6 1167.95  5229.3 1170.84
  5249.4 1173.15  5289.5 1174.28  5300.8 1176.87  5319.6 1178.07  5409.9 1177.35
#Mann=9,-1,0
  4281.7    0.05       0  4420.0    0.12       0  4913.4    0.05       0
  4944.1    0.12       0  4982.1    0.07       0  5003.6    0.12       0
  5022.6    0.05       0  5176.6    0.12       0  5300.8    0.05       0
Bank Sta=4982.1,5003.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,37846,334,334,334
BEGIN DESCRIPTION:
HONEY CREEK 67.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2851155.69     10200703.07      2851276.75     10200143.00
      2850905.67     10199853.10
#Sta/Elev= 30
  4427.0 1161.00  4550.1 1153.15  4600.9 1147.19  4662.3 1143.43  4713.4 1144.02
  4731.7 1145.91  4743.2 1144.56  4753.0 1143.58  4795.3 1147.18  4846.4 1145.46
  4874.3 1142.44  4879.4 1143.41  4907.8 1138.38  4918.0 1139.70  4923.6 1139.20
  4928.7 1137.01  4942.5 1136.42  4972.8 1132.78  4979.4 1130.05  4997.1 1128.85
  4997.6 1128.35  5018.6 1128.85  5036.8 1130.41  5072.0 1129.45  5121.8 1130.54
  5162.7 1135.80  5200.5 1140.41  5320.8 1145.40  5428.4 1156.76  5470.9 1156.84
#Mann=7,-1,0
  4427.0    0.05       0  4743.2    0.12       0  4753.0    0.05       0
  4942.5    0.12       0  4997.1    0.07       0  5018.6    0.12       0
  5162.7    0.05       0
Bank Sta=4997.1,5018.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,37512,769,769,769
BEGIN DESCRIPTION:
Mapping XS 56bae183
END DESCRIPTION:
XS GIS Cut Line= 3
      2851502.63     10201082.30      2851619.81     10200066.66
      2850864.59     10198842.68
#Sta/Elev= 30
  4106.9 1143.97  4166.5 1147.86  4287.3 1136.64  4436.1 1147.72  4569.1 1137.74
  4679.9 1119.92  4730.2 1131.87  4800.7 1110.25  4824.3 1116.77  4840.9 1119.21
  4875.6 1106.86  4941.6 1113.92  5022.1 1092.46  5061.7 1092.06  5062.2 1091.56
  5083.2 1092.06  5102.6 1110.69  5128.5 1115.98  5170.1 1103.55  5228.1 1121.88
  5359.4 1125.23  5417.3 1122.58  5527.3 1098.37  5606.5 1123.02  5690.5 1133.43
  5832.4 1145.62  6253.4 1151.47  6296.7 1160.35  6390.7 1150.47  6567.5 1159.63
#Mann=5,-1,0
  4106.9    0.05       0  4824.3    0.12       0  5061.7    0.07       0
  5083.2    0.12       0  5690.5    0.05       0
Bank Sta=5061.7,5083.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,36743,1619,1619,1619
BEGIN DESCRIPTION:
Mapping XS 52b4ccad
END DESCRIPTION:
XS GIS Cut Line= 3
      2852401.06     10201134.33      2852322.94     10199715.10
      2851529.66     10198414.64
#Sta/Elev= 30
  3966.9 1153.61  4058.3 1154.46  4218.5 1148.39  4358.7 1130.62  4849.5 1105.89
  4884.0 1102.31  4915.5 1090.68  4959.6 1081.44  4968.5 1076.25  4969.0 1075.75
  4990.8 1076.25  5019.7 1078.52  5089.8 1096.75  5201.7 1104.89  5613.2 1106.75
  5889.9 1098.50  6021.8 1097.57  6070.3 1086.80  6101.2 1086.41  6138.0 1092.21
  6201.9 1091.17  6407.1 1107.77  6413.0 1105.07  6428.4 1110.73  6449.7 1109.15
  6486.2 1118.64  6544.6 1127.21  6632.3 1124.91  6684.4 1131.00  6911.6 1141.01
#Mann=8,-1,0
  3966.9    0.05       0  4915.5    0.12       0  4968.5    0.07       0
  4990.8    0.12       0  5201.7    0.05       0  5889.9    0.12       0
  6486.2    0.05       0  6684.4    0.12       0
Bank Sta=4968.5,4990.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,35124,550,550,550
BEGIN DESCRIPTION:
HONEY CREEK 62.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854305.66     10200103.08      2853733.00     10199324.00
      2852455.69     10198603.11
#Sta/Elev= 30
  4033.1 1237.76  4189.1 1181.50  4255.6 1163.58  4312.0 1158.18  4362.1 1148.05
  4397.6 1125.25  4412.3 1119.57  4433.1 1119.57  4483.3 1110.71  4504.4 1104.17
  4577.4 1087.91  4663.0 1079.42  4849.0 1072.26  4869.8 1073.68  5008.6 1064.02
  5009.1 1063.52  5031.1 1064.02  5050.6 1067.52  5056.4 1074.05  5072.3 1076.78
  5078.0 1083.97  5146.2 1087.14  5622.5 1082.95  5886.8 1086.10  5951.8 1079.52
  5989.8 1080.98  6135.2 1087.19  6253.7 1099.96  6340.4 1119.60  6466.7 1126.12
#Mann=6,-1,0
  4033.1    0.05       0  4189.1    0.12       0  4504.4    0.05       0
  5008.6    0.05       0  5031.1    0.05       0  5989.8    0.12       0
Bank Sta=5008.6,5031.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,34574,409,409,409
BEGIN DESCRIPTION:
HONEY CREEK 61.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854515.38     10199833.21      2854267.25     10199213.00
      2852951.77     10198173.36
#Sta/Elev= 30
  4332.0 1163.35  4394.9 1150.33  4472.1 1147.68  4561.8 1149.17  4622.9 1143.81
  4669.5 1124.29  4693.8 1105.77  4730.6 1090.26  4763.5 1081.26  4838.3 1072.87
  4938.8 1070.21  4963.0 1064.47  5011.3 1061.12  5011.8 1060.62  5033.8 1061.12
  5121.9 1071.08  5280.5 1072.73  5402.2 1079.06  5612.8 1082.55  5805.0 1082.73
  5825.0 1077.63  5868.9 1070.85  5897.7 1071.63  5926.6 1077.82  6253.6 1075.44
  6410.7 1083.18  6545.3 1081.90  6567.8 1088.20  6617.5 1091.54  6676.7 1100.08
#Mann=8,-1,0
  4332.0    0.12       0  4763.5    0.05       0  5011.3    0.05       0
  5033.8    0.05       0  5280.5    0.12       0  5402.2    0.05       0
  5612.8    0.12       0  5825.0    0.05       0
Bank Sta=5011.3,5033.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,34165,863,863,863
BEGIN DESCRIPTION:
HONEY CREEK 60.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854755.67     10199303.09      2854570.50     10199022.00
      2853204.35     10198059.09
#Sta/Elev= 30
  4663.4 1131.31  4670.9 1128.85  4676.9 1120.44  4713.0 1109.20  4815.5 1096.50
  4836.5 1088.97  4909.0 1077.73  4929.9 1070.60  4945.0 1070.84  4950.9 1062.31
  4960.0 1061.52  4966.0 1054.31  4974.7 1058.53  4975.8 1053.70  4976.3 1053.20
  4998.3 1053.70  5053.8 1060.52  5131.3 1060.88  5213.4 1067.93  5389.9 1065.69
  5503.3 1071.25  5650.5 1076.81  6089.5 1077.32  6195.3 1073.56  6315.0 1074.08
  6365.3 1066.11  6394.9 1071.64  6466.3 1069.15  6523.0 1080.20  6671.4 1091.82
#Mann=9,-1,0
  4663.4    0.12       0  4909.0    0.05       0  4975.8    0.07       0
  4998.3    0.05       0  5213.4    0.05       0  5503.3    0.12       0
  5650.5    0.05       0  6089.5    0.12       0  6195.3    0.05       0
Bank Sta=4975.8,4998.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,33302,381,381,381
BEGIN DESCRIPTION:
Mapping XS beff0359
END DESCRIPTION:
XS GIS Cut Line= 3
      2854927.11     10199311.43      2854940.13     10198621.35
      2854848.98     10197801.01
#Sta/Elev= 30
  4188.4 1116.97  4313.6 1117.72  4366.8 1115.65  4396.8 1112.02  4426.8 1103.53
  4466.8 1096.97  4506.8 1083.35  4546.8 1081.02  4596.8 1075.42  4676.8 1069.55
  4756.8 1066.53  4836.8 1061.19  4875.2 1057.12  4907.0 1055.91  4968.3 1048.71
  4970.7 1046.58  4971.3 1046.08  5004.3 1046.58  5037.8 1051.80  5108.3 1055.08
  5144.3 1061.24  5210.8 1062.82  5421.0 1071.40  5500.7 1076.87  5506.6 1078.16
  5511.6 1077.38  5597.1 1083.37  5602.1 1082.30  5661.6 1084.38  5704.0 1082.67
#Mann=5,-1,0
  4188.4    0.05       0  4313.6    0.12       0  4970.7    0.07       0
  5004.3    0.12       0  5210.8    0.05       0
Bank Sta=4970.7,5004.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,32921,329,329,329
BEGIN DESCRIPTION:
HONEY CREEK 58.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2855105.69     10198903.10      2855305.00     10198524.00
      2855555.71     10198153.08
#Sta/Elev= 30
  4571.7 1089.08  4662.1 1087.73  4728.5 1083.56  4734.2 1085.43  4816.7 1070.61
  4822.4 1072.86  4827.4 1071.65  4838.7 1068.30  4870.1 1070.11  4910.6 1068.73
  4921.3 1066.06  4926.9 1062.84  4933.2 1055.54  4943.3 1050.94  4949.0 1051.79
  4965.3 1046.81  4971.0 1047.55  4976.2 1044.01  4976.8 1043.51  5009.8 1044.01
  5022.4 1045.82  5059.6 1044.13  5091.4 1045.58  5137.7 1047.49  5173.5 1048.68
  5188.4 1051.71  5260.4 1056.60  5339.0 1077.29  5411.5 1091.15  5447.7 1094.53
#Mann=8,-1,0
  4571.7    0.05       0  4827.4    0.12       0  4870.1    0.05       0
  4976.2    0.05       0  5009.8    0.05       0  5022.4    0.12       0
  5091.4    0.05       0  5137.7    0.12       0
Bank Sta=4976.2,5009.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,32592,727,727,727
BEGIN DESCRIPTION:
Mapping XS b765bbbf
END DESCRIPTION:
XS GIS Cut Line= 3
      2855408.89     10199103.09      2855591.17     10198634.37
      2855682.31     10198139.61
#Sta/Elev= 30
  4320.8 1075.05  4464.7 1068.90  4494.6 1067.17  4513.7 1064.80  4573.5 1066.32
  4603.4 1064.17  4621.2 1065.34  4664.1 1063.21  4682.3 1063.94  4687.7 1062.44
  4760.7 1058.64  4865.7 1050.85  4916.5 1043.25  4977.5 1042.08  4981.0 1039.77
  4981.7 1039.27  5014.7 1039.77  5018.2 1042.65  5028.7 1042.52  5042.7 1041.49
  5058.9 1045.13  5079.2 1045.29  5089.4 1048.40  5095.7 1053.44  5100.8 1052.69
  5119.9 1063.36  5160.5 1080.00  5206.9 1090.55  5252.1 1095.21  5326.8 1099.46
#Mann=4,-1,0
  4320.8    0.05       0  4981.0    0.05       0  5014.7    0.05       0
  5028.7    0.12       0
Bank Sta=4981,5014.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,31865,584,584,584
BEGIN DESCRIPTION:
HONEY CREEK 56.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2855855.65     10199003.13      2856231.25     10198842.00
      2856205.69     10198403.14
#Sta/Elev= 30
  4591.3 1065.95  4658.4 1062.50  4886.8 1043.96  4933.9 1040.97  4972.2 1037.20
  4981.1 1035.93  4982.8 1033.50  4983.5 1033.00  5016.5 1033.50  5018.9 1035.19
  5028.9 1035.89  5039.0 1035.92  5049.0 1034.10  5059.0 1035.56  5079.0 1034.85
  5101.4 1035.47  5139.1 1037.51  5159.2 1037.47  5177.9 1040.51  5182.9 1039.17
  5199.2 1042.29  5229.3 1049.86  5249.3 1059.11  5279.4 1071.48  5289.4 1074.68
  5329.4 1081.02  5339.5 1083.44  5354.1 1085.65  5428.3 1086.48  5439.6 1086.63
#Mann=6,-1,0
  4591.3    0.05       0  4886.8    0.12       0  4982.8    0.07       0
  5016.5    0.12       0  5101.4    0.12       0  5428.3    0.05       0
Bank Sta=4982.8,5016.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,31281,585,585,585
BEGIN DESCRIPTION:
HONEY CREEK 55.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856305.71     10199603.08      2856562.50     10199296.00
      2856855.67     10199003.12
#Sta/Elev= 30
  4599.7 1059.08  4670.6 1053.70  4684.9 1050.46  4748.7 1042.85  4763.0 1045.22
  4769.5 1044.12  4777.3 1045.12  4820.2 1041.56  4869.7 1034.39  4876.2 1031.91
  4908.7 1026.60  4909.3 1026.10  4942.6 1026.60  4947.8 1028.10  4954.3 1026.68
  5062.7 1029.41  5082.1 1030.81  5110.4 1038.00  5124.5 1043.96  5138.6 1047.96
  5188.1 1051.94  5237.6 1051.76  5273.0 1057.72  5287.1 1058.86  5294.2 1057.76
  5315.4 1061.68  5343.7 1064.69  5379.1 1065.76  5411.0 1069.32  5414.4 1069.32
#Mann=5,-1,0
  4599.7    0.05       0  4908.7    0.05       0  4942.6    0.05       0
  5062.7    0.12       0  5411.0    0.05       0
Bank Sta=4908.7,4942.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,30696,571,571,571
BEGIN DESCRIPTION:
HONEY CREEK 54.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856555.70     10200103.10      2856837.50     10199791.00
      2856905.68     10199053.14
#Sta/Elev= 30
  4579.5 1068.72  4607.5 1069.05  4657.6 1066.57  4727.8 1059.32  4756.2 1056.90
  4776.6 1056.12  4890.7 1044.75  4919.1 1038.07  4926.6 1034.48  4955.0 1025.50
  4983.4 1019.34  5000.0 1019.17  5001.0 1017.61  5001.7 1017.11  5034.9 1017.61
  5038.8 1020.20  5068.2 1019.56  5098.3 1020.30  5143.4 1023.29  5159.0 1025.39
  5188.7 1029.19  5357.5 1037.38  5379.5 1039.56  5429.7 1046.82  5544.4 1054.31
  5620.5 1058.45  5686.2 1064.80  5691.3 1064.26  5710.9 1066.68  5741.0 1068.71
#Mann=6,-1,0
  4579.5    0.12       0  4776.6    0.05       0  5001.0    0.05       0
  5034.9    0.05       0  5159.0    0.12       0  5544.4    0.05       0
Bank Sta=5001,5034.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,30125,196,196,196
BEGIN DESCRIPTION:
HONEY CREEK 53.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2857405.68     10200453.06      2857366.75     10199961.00
      2857305.69     10199553.15
#Sta/Elev= 30
  4506.4 1055.94  4526.4 1054.72  4576.6 1046.79  4596.6 1045.27  4676.9 1034.74
  4699.2 1029.91  4807.3 1022.02  4822.8 1022.95  4827.8 1019.89  4847.4 1018.84
  4867.5 1012.05  4887.5 1014.64  4927.7 1017.23  4946.4 1016.32  4951.4 1017.47
  4996.4 1010.50  5025.2 1010.26  5025.9 1009.76  5059.1 1010.26  5068.6 1013.72
  5111.3 1013.79  5155.5 1017.76  5169.8 1018.66  5175.4 1020.41  5180.5 1020.05
  5210.2 1024.94  5292.0 1029.76  5341.7 1035.72  5392.0 1037.98  5412.4 1039.81
#Mann=6,-1,0
  4506.4    0.12       0  5025.2    0.07       0  5059.1    0.12       0
  5155.5    0.05       0  5292.0    0.12       0  5392.0    0.05       0
Bank Sta=5025.2,5059.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,29929,357,357,357
BEGIN DESCRIPTION:
Mapping XS aeb69557
END DESCRIPTION:
XS GIS Cut Line= 3
      2857843.81     10200503.50      2857566.03     10200182.32
      2857522.72     10199506.64
#Sta/Elev= 30
  4390.2 1042.63  4403.1 1042.38  4410.4 1040.50  4424.7 1040.74  4431.3 1038.03
  4445.5 1039.40  4453.2 1037.61  4459.8 1039.88  4467.4 1035.95  4474.0 1037.51
  4481.7 1034.93  4502.5 1033.77  4509.7 1030.52  4516.8 1030.13  4545.3 1030.22
  4551.9 1033.56  4580.4 1036.13  4637.4 1030.86  4672.6 1032.99  4750.4 1030.45
  4898.8 1019.86  4934.3 1011.65  4984.4 1011.60  4987.2 1009.80  4987.9 1009.30
  5021.6 1009.80  5104.6 1016.92  5184.8 1019.45  5368.8 1030.14  5491.9 1033.78
#Mann=4,-1,0
  4390.2    0.12       0  4403.1    0.05       0  4987.2    0.05       0
  5021.6    0.05       0
Bank Sta=4987.2,5021.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,29572,596,596,596
BEGIN DESCRIPTION:
HONEY CREEK 52.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2858105.70     10200453.14      2857868.25     10200120.00
      2857955.68     10199453.11
#Sta/Elev= 30
  4590.9 1063.81  4604.4 1062.19  4619.2 1058.32  4706.4 1050.70  4799.7 1041.94
  4827.0 1038.07  4841.7 1034.42  4856.5 1038.32  4866.9 1037.27  4885.7 1035.09
  4906.9 1028.15  4921.6 1018.64  4934.8 1011.59  4963.4 1008.45  4971.6 1004.65
  4975.7 1004.59  4976.4 1004.09  5010.1 1004.59  5015.4 1006.12  5020.4 1005.26
  5027.1 1007.02  5047.3 1008.22  5105.7 1006.12  5138.1 1011.81  5173.0 1010.98
  5241.8 1018.88  5349.9 1025.28  5425.7 1031.16  5629.2 1047.90  5672.6 1050.26
#Mann=9,-1,0
  4590.9    0.12       0  4706.4    0.05       0  4866.9    0.12       0
  4975.7    0.07       0  5010.1    0.12       0  5105.7    0.05       0
  5241.8    0.12       0  5425.7    0.05       0  5629.2    0.12       0
Bank Sta=4975.7,5010.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,28976,584,584,584
BEGIN DESCRIPTION:
HONEY CREEK 51.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2858355.69     10200403.08      2858421.50     10199974.00
      2858205.69     10199453.14
#Sta/Elev= 30
  4565.9 1067.22  4646.8 1058.00  4677.2 1052.29  4717.6 1055.04  4733.6 1054.17
  4758.1 1054.88  4788.4 1053.89  4861.0 1039.96  4863.5 1039.85  4869.4 1036.14
  4920.0 1019.15  4926.8 1013.67  4931.9 1014.09  4940.2 1010.43  4959.8 1005.30
  4970.5 1003.04  4980.7  997.81  4981.4  997.31  5015.1  997.81  5044.3 1000.04
  5069.9 1004.60  5110.6 1007.73  5120.0 1009.87  5134.5 1009.44  5172.5 1013.13
  5195.8 1016.79  5259.4 1020.81  5280.8 1023.87  5437.3 1035.05  5563.8 1046.44
#Mann=10,-1,0
  4565.9    0.12       0  4733.6    0.05       0  4861.0    0.12       0
  4959.8    0.05       0  4980.7    0.05       0  5015.1    0.05       0
  5069.9    0.12       0  5172.5    0.05       0  5280.8    0.12       0
  5437.3    0.05       0
Bank Sta=4980.7,5015.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,28392,565,565,565
BEGIN DESCRIPTION:
HONEY CREEK 50.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2858905.68     10200253.12      2858989.25     10199855.00
      2858855.69     10199303.13
#Sta/Elev= 30
  4593.2 1060.33  4685.2 1053.31  4762.7 1042.33  4767.8 1042.75  4787.4 1039.30
  4832.3 1034.49  4848.7 1032.90  4857.4 1030.29  4862.5 1032.26  4907.2 1017.64
  4912.4 1018.66  4940.6 1007.83  4971.3 1002.82  4995.0  996.05  4995.7  995.55
  5029.5  996.05  5032.0  997.70  5037.2  997.98  5053.4  996.79  5073.9 1002.03
  5156.3 1006.31  5167.8 1009.10  5218.0 1015.90  5288.2 1021.26  5300.3 1023.72
  5403.2 1034.86  5418.8 1038.00  5507.6 1046.36  5565.8 1054.18  5567.8 1054.18
#Mann=5,-1,0
  4593.2    0.05       0  4832.3    0.12       0  4995.0    0.07       0
  5029.5    0.12       0  5565.8    0.05       0
Bank Sta=4995,5029.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,27827,565,565,565
BEGIN DESCRIPTION:
HONEY CREEK 49.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2859805.65     10199903.08      2859501.75     10199624.00
      2858905.64     10199303.09
#Sta/Elev= 30
  4587.4 1059.41  4708.1 1041.68  4785.6 1028.79  4806.5 1022.99  4849.1 1014.01
  4863.3 1007.78  4877.5 1004.18  4930.3  996.30  4955.1  993.78  4976.7  993.32
  4979.7  990.57  4980.4  990.07  5014.2  990.57  5028.7  993.33  5041.0  997.65
  5054.6  997.87  5109.1  999.50  5126.5 1001.62  5160.2 1005.13  5242.1 1010.83
  5269.7 1014.10  5351.7 1019.20  5383.4 1021.64  5395.4 1024.43  5411.7 1025.12
  5417.3 1027.05  5439.2 1029.18  5499.3 1032.17  5597.4 1040.95  5677.0 1051.23
#Mann=9,-1,0
  4587.4    0.12       0  4708.1    0.05       0  4930.3    0.12       0
  4979.7    0.07       0  5014.2    0.12       0  5054.6    0.05       0
  5126.5    0.12       0  5351.7    0.05       0  5383.4    0.12       0
Bank Sta=4979.7,5014.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,27262,489,489,489
BEGIN DESCRIPTION:
HONEY CREEK 48.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2859955.69     10199753.08      2859972.50     10199316.00
      2859705.69     10199003.12
#Sta/Elev= 30
  4562.6 1046.78  4673.1 1031.75  4683.4 1030.36  4712.7 1026.95  4752.7 1020.32
  4762.7 1017.24  4792.7 1011.60  4822.8 1007.53  4862.8  999.77  4912.8  993.26
  4942.8  991.01  4950.3  989.25  4955.3  990.63  4962.9  987.94  4972.9  988.23
  4981.6  986.34  4982.3  985.84  5016.3  986.34  5042.8  993.99  5070.3  995.19
  5127.4 1003.04  5163.9 1005.90  5184.5 1008.27  5191.0 1009.61  5198.8 1013.09
  5233.9 1018.88  5297.9 1021.37  5326.1 1023.80  5407.7 1025.72  5411.2 1025.74
#Mann=8,-1,0
  4562.6    0.12       0  4673.1    0.05       0  4683.4    0.12       0
  4981.6    0.07       0  5016.3    0.12       0  5163.9    0.05       0
  5297.9    0.12       0  5407.7    0.05       0
Bank Sta=4981.6,5016.3
Exp/Cntr=0.3,0.1
