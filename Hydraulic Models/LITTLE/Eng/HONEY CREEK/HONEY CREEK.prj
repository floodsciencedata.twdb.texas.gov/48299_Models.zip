HEC-RAS study HONEY CREEK.prj: HONEY CREEK Base Level Engineering

--- HONEY CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,26773,529,529,529
BEGIN DESCRIPTION:
Mapping XS 7d534a14
END DESCRIPTION:
XS GIS Cut Line= 2
      2860500.03     10199715.14      2860317.73     10198530.18
#Sta/Elev= 30
  4373.5 1018.16  4433.1 1016.99  4446.4 1019.22  4527.3 1019.72  4702.3 1013.69
  4779.3 1009.47  4832.7 1005.15  4871.3  996.32  4979.5  984.27  4995.6  983.39
  4996.3  982.89  5030.4  983.39  5033.2  988.92  5083.8  991.44  5104.0  995.73
  5159.0 1001.53  5174.8 1011.30  5185.0 1013.35  5228.2 1014.85  5285.5 1017.99
  5290.5 1016.23  5296.3 1016.82  5353.8 1029.80  5358.8 1028.42  5379.9 1031.76
  5397.4 1035.10  5427.8 1036.85  5490.4 1026.82  5559.3 1019.22  5572.4 1019.21
#Mann=8,-1,0
  4373.5    0.05       0  4702.3    0.12       0  4779.3    0.05       0
  4979.5    0.12       0  4995.6    0.07       0  5030.4    0.12       0
  5228.2    0.05       0  5379.9    0.12       0
Bank Sta=4995.6,5030.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,26244,590,590,590
BEGIN DESCRIPTION:
HONEY CREEK 46.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2860855.69     10199403.06      2860903.75     10198930.00
      2860755.70     10198553.14
#Sta/Elev= 30
  4524.5 1026.28  4544.6 1025.13  4571.8 1021.10  4715.4 1009.43  4846.1  994.92
  4886.3  992.50  4907.5  989.26  4965.7  981.09  4970.7  981.53  4978.5  978.62
  4979.2  978.12  5013.4  978.62  5018.1  981.26  5035.0  985.09  5071.9  990.94
  5082.6 1000.97  5089.2 1012.41  5094.6 1016.47  5104.1 1019.33  5143.4 1024.86
  5148.8 1023.92  5174.3 1025.16  5197.6 1027.62  5227.4 1027.32  5243.8 1032.08
  5281.6 1035.85  5287.0 1035.01  5310.3 1038.07  5339.5 1042.97  5404.9 1047.38
#Mann=7,-1,0
  4524.5    0.05       0  4907.5    0.12       0  4978.5    0.07       0
  5013.4    0.12       0  5174.3    0.05       0  5310.3    0.12       0
  5339.5    0.05       0
Bank Sta=4978.5,5013.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,25654,593,593,593
BEGIN DESCRIPTION:
HONEY CREEK 45.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2861605.70     10199353.16      2861475.25     10198795.00
      2861105.67     10198553.11
#Sta/Elev= 30
  4426.8 1032.88  4529.5 1020.13  4601.4 1014.68  4652.8 1012.95  4683.6 1009.71
  4716.0 1003.40  4786.3  998.44  4827.4  992.80  4939.9  982.33  4971.1  978.62
  4974.2  975.82  4975.0  975.32  5009.1  975.82  5045.2  978.38  5072.3  983.30
  5081.4  983.89  5087.4  990.66  5095.1  989.89  5102.5  992.40  5108.4  998.88
  5153.8 1004.22  5196.2 1013.13  5217.0 1016.99  5247.2 1019.86  5340.7 1022.00
  5361.8 1021.11  5376.9 1022.44  5382.8 1021.33  5390.9 1022.43  5441.7 1025.31
#Mann=6,-1,0
  4426.8    0.05       0  4939.9    0.12       0  4974.2    0.07       0
  5009.1    0.12       0  5196.2    0.05       0  5390.9    0.12       0
Bank Sta=4974.2,5009.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,25061,621,621,621
BEGIN DESCRIPTION:
HONEY CREEK 44.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2862355.69     10199003.12      2862054.25     10198692.00
      2861855.71     10198303.16
#Sta/Elev= 30
  4566.8 1030.95  4609.1 1025.80  4616.3 1023.31  4623.3 1022.57  4644.6 1016.97
  4701.2 1004.86  4757.8  996.73  4764.8  997.66  4774.1  996.42  4828.5  990.37
  4863.8  988.74  4934.5  982.99  4948.7  981.03  4955.9  978.84  4962.8  978.97
  4966.7  975.69  4967.4  975.19  5001.7  975.69  5028.3  976.03  5050.6  979.05
  5056.2  978.82  5066.1  982.38  5072.8  986.46  5078.4  986.28  5088.6  988.75
  5139.4  991.07  5206.1  991.88  5334.8  999.46  5406.1 1009.54  5436.6 1011.89
#Mann=5,-1,0
  4566.8    0.05       0  4774.1    0.12       0  4966.7    0.07       0
  5001.7    0.12       0  5334.8    0.05       0
Bank Sta=4966.7,5001.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,24440,448,448,448
BEGIN DESCRIPTION:
Mapping XS d48ec6bf
END DESCRIPTION:
XS GIS Cut Line= 2
      2862895.83     10198777.57      2862154.93     10197906.69
#Sta/Elev= 30
  4487.4 1023.52  4505.3 1026.71  4532.7 1028.13  4589.8 1027.88  4675.5 1023.65
  4736.3 1015.62  4782.1 1006.83  4788.6 1004.90  4802.9  995.99  4823.7  988.64
  4838.0  985.84  4923.7  975.28  4965.9  971.63  4973.1  972.30  4984.2  970.35
  4984.9  969.85  5019.2  970.35  5022.5  975.23  5086.2  984.67  5093.9  984.04
  5140.4  987.35  5285.7  992.28  5354.0  991.44  5385.0  990.87  5412.4  993.64
  5518.9  999.03  5540.9 1001.53  5561.7 1000.82  5596.9 1002.40  5630.8 1005.58
#Mann=7,-1,0
  4487.4    0.05       0  4736.3    0.12       0  4984.2    0.07       0
  5019.2    0.12       0  5140.4    0.05       0  5285.7    0.12       0
  5354.0    0.05       0
Bank Sta=4984.2,5019.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,23992,833,833,833
BEGIN DESCRIPTION:
HONEY CREEK 42.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2863005.69     10198453.13      2862868.25     10198066.00
      2862455.66     10197603.08
#Sta/Elev= 30
  4589.2 1015.54  4642.3 1013.13  4714.3 1007.16  4779.2 1001.24  4790.8  998.34
  4815.4  994.75  4833.3  987.81  4840.9  983.57  4854.5  979.19  4928.2  973.42
  4933.5  971.76  4950.0  969.96  4971.2  969.40  4972.4  968.15  4973.1  967.65
  5007.5  968.15  5011.0  971.04  5025.2  973.75  5170.2  982.40  5286.9  987.07
  5372.2  992.58  5429.0  998.74  5449.9 1003.66  5485.9 1007.20  5513.5 1012.22
  5592.0 1019.33  5606.3 1021.69  5613.0 1024.72  5616.7 1022.07  5620.1 1022.07
#Mann=5,-1,0
  4589.2    0.05       0  4714.3    0.12       0  4972.4    0.07       0
  5007.5    0.12       0  5170.2    0.05       0
Bank Sta=4972.4,5007.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,23159,709,709,709
BEGIN DESCRIPTION:
Mapping XS 45bb4d55
END DESCRIPTION:
XS GIS Cut Line= 4
      2863182.31     10198334.94      2863286.48     10197696.87
      2863325.54     10197358.33      2861959.52     10197163.18
#Sta/Elev= 30
  4149.4 1006.52  4455.2  990.73  4669.1  984.25  4890.3  975.43  4960.8  967.10
  4980.9  959.96  4994.0  959.94  4994.8  959.44  5029.1  959.94  5061.4  970.17
  5090.5  989.70  5095.5  988.54  5121.3  995.64  5160.3  998.92  5259.4 1007.18
  5288.1 1012.02  5358.6 1001.65  5457.7  993.47  5500.2  991.20  5692.1  997.85
  5823.5  997.15  5904.3  993.08  5983.4  999.72  6052.5 1000.90  6151.6  994.84
  6287.8 1007.02  6318.4 1009.51  6379.0 1021.09  6419.5 1018.66  6516.6 1017.04
#Mann=13,-1,0
  4149.4    0.05       0  4669.1    0.12       0  4994.0    0.07       0
  5029.1    0.12       0  5121.3    0.05       0  5160.3    0.12       0
  5259.4    0.05       0  5358.6    0.12       0  5457.7    0.05       0
  6052.5    0.12       0  6151.6    0.05       0  6287.8    0.12       0
  6419.5    0.05       0
Bank Sta=4994,5029.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,22450,437,437,437
BEGIN DESCRIPTION:
Mapping XS ea883ada
END DESCRIPTION:
XS GIS Cut Line= 4
      2863325.53     10198400.02      2863833.36     10197592.71
      2864106.79     10196902.60      2864392.80     10195966.58
#Sta/Elev= 30
  3686.0 1007.29  3916.9  987.78  4168.9  982.69  4357.3  982.44  4527.6  996.88
  4543.6  998.34  4618.8  999.98  4681.9  994.15  4687.3  996.47  4711.6  990.05
  4835.6  974.01  4873.7  967.30  4933.1  963.32  4957.5  958.58  5021.7  957.36
  5022.7  956.86  5060.6  957.36  5065.5  963.47  5227.6  981.54  5317.0  981.33
  5454.7  973.63  5570.7  976.23  5610.1  980.44  5716.0  985.31  5935.7  994.10
  6062.3 1005.22  6143.9 1015.23  6220.0 1008.93  6315.5 1008.22  6360.8 1010.57
#Mann=11,-1,0
  3686.0    0.05       0  4527.6    0.12       0  4543.6    0.05       0
  4835.6    0.12       0  4933.1    0.05       0  5021.7    0.03       0
  5060.6    0.05       0  5610.1    0.12       0  5716.0    0.05       0
  6062.3    0.12       0  6315.5    0.05       0
Bank Sta=5021.7,5060.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,22013,911,911,911
BEGIN DESCRIPTION:
Mapping XS a13fcffb
END DESCRIPTION:
XS GIS Cut Line= 4
      2863351.62     10198972.88      2863898.46     10198400.00
      2864510.44     10197032.81      2864653.66     10196459.92
#Sta/Elev= 30
  3019.5  995.67  3227.2  985.84  3376.0  984.43  3736.7  976.41  4185.1  981.08
  4290.1  980.02  4428.0  982.65  4520.2  980.70  4601.3  976.81  4782.9  973.16
  4837.9  969.89  4903.7  959.68  4988.7  956.48  5016.2  957.00  5049.9  956.33
  5050.9  955.83  5088.8  956.33  5092.6  960.93  5110.3  960.33  5115.7  962.68
  5133.5  958.86  5138.9  960.01  5167.6  958.08  5237.2  964.19  5260.4  968.80
  5311.0  971.63  5477.2  981.33  5566.8  991.23  5801.9  997.90  5899.9  996.65
#Mann=7,-1,0
  3019.5    0.05       0  4782.9    0.12       0  4988.7    0.05       0
  5016.2    0.12       0  5049.9    0.05       0  5088.8    0.12       0
  5311.0    0.05       0
Bank Sta=5049.9,5088.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,21102,980,980,980
BEGIN DESCRIPTION:
Mapping XS acdad498
END DESCRIPTION:
XS GIS Cut Line= 4
      2863520.89     10199402.57      2864302.11     10198504.16
      2865096.38     10197696.87      2865395.84     10197202.11
#Sta/Elev= 30
  3256.5  992.78  3373.3  986.47  3486.2  975.09  3883.1  975.20  3961.0  971.21
  4230.7  981.93  4446.0 1004.67  4521.0 1004.21  4605.9  993.15  4641.3  992.77
  4690.7  983.10  4754.4  991.25  4796.9  989.72  4853.4  981.39  4917.0  955.96
  4949.6  951.79  5016.6  946.64  5017.6  946.14  5058.0  946.64  5058.5  951.32
  5171.6  966.43  5251.3  970.11  5382.7  980.05  5481.9  987.11  5625.7  996.98
  5705.2  995.80  5742.1  999.59  5901.2  990.86  6011.7 1008.00  6157.9 1007.69
#Mann=7,-1,0
  3256.5    0.05       0  4949.6    0.12       0  5016.6    0.07       0
  5058.0    0.12       0  5251.3    0.05       0  5382.7    0.12       0
  5481.9    0.05       0
Bank Sta=5016.6,5058
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,20122,1045,1045,1045
BEGIN DESCRIPTION:
Mapping XS 75c69c23
END DESCRIPTION:
XS GIS Cut Line= 4
      2863729.22     10200027.57      2864562.52     10199324.48
      2865161.48     10198920.83      2865811.47     10198348.84
#Sta/Elev= 30
  3369.5  995.21  3476.7  983.22  3511.8  989.26  3597.6  980.73  3618.4  984.74
  3710.7  979.97  3788.7  964.90  3817.3  971.19  3838.2  964.43  3966.7  966.67
  4122.9  955.03  4150.2  962.93  4186.6  959.81  4285.4  975.49  4521.4  991.17
  4665.3  971.42  4722.3  970.45  4874.0  953.61  4989.1  940.12  4990.1  939.62
  5031.1  940.12  5181.6  964.71  5219.6  961.02  5318.3  959.42  5353.4  952.65
  5516.6  968.80  5566.0  979.87  5594.4  977.51  5672.2  988.89  6047.9 1014.63
#Mann=5,-1,0
  3369.5    0.05       0  4874.0    0.12       0  4989.1    0.07       0
  5031.1    0.12       0  5219.6    0.05       0
Bank Sta=4989.1,5031.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,19077,753,753,753
BEGIN DESCRIPTION:
Mapping XS 38dc3eb7
END DESCRIPTION:
XS GIS Cut Line= 3
      2864263.35     10200416.05      2865756.39     10199738.97
      2866310.57     10199357.98
#Sta/Elev= 30
  4050.5  990.90  4272.7  985.93  4478.6  975.80  4823.7  953.90  4944.7  942.45
  4975.4  936.36  4976.3  933.88  4977.3  933.38  5018.5  933.88  5018.9  934.15
  5052.3  941.33  5111.8  945.79  5157.9  961.85  5236.6  974.12  5376.7  993.45
  5382.2  990.86  5399.8  993.69  5405.3  991.96  5446.0  999.36  5451.4  996.89
  5491.5 1000.50  5579.3 1020.67  5678.1 1031.56  5758.9 1033.00  5815.7 1029.18
  5851.6 1034.92  5908.4 1035.37  6024.8 1029.91  6326.5 1008.28  6362.4 1008.48
#Mann=5,-1,0
  4050.5    0.05       0  4976.3    0.05       0  5018.5    0.05       0
  5018.9    0.12       0  5236.6    0.05       0
Bank Sta=4976.3,5018.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,18324,1141,1141,1141
BEGIN DESCRIPTION:
Mapping XS d9a82107
END DESCRIPTION:
XS GIS Cut Line= 3
      2864489.07     10201179.92      2865339.72     10200745.92
      2866120.07     10200277.71
#Sta/Elev= 30
  4031.2  974.96  4100.8  970.95  4139.6  977.49  4145.2  980.59  4211.9  983.66
  4250.8  978.96  4278.6  983.46  4300.8  982.96  4361.9  976.81  4367.5  979.29
  4389.7  980.74  4406.4  978.38  4456.4  980.34  4539.7  971.03  4612.0  973.79
  4717.6  967.02  4845.3  953.55  4858.1  954.75  4867.5  949.82  4956.5  932.24
  4983.8  931.58  4984.8  928.96  4985.8  928.46  5027.1  928.96  5101.2  939.07
  5598.8  968.40  5662.9  975.43  5721.2  987.30  5786.1  996.14  5896.2 1004.60
#Mann=3,-1,0
  4031.2    0.05       0  4984.8    0.03       0  5027.1    0.05       0
Bank Sta=4984.8,5027.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,17183,588,588,588
BEGIN DESCRIPTION:
HONEY CREEK 30.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865805.68     10201703.11      2866137.75     10201444.00
      2866455.67     10200753.14
#Sta/Elev= 30
  4578.8  975.95  4685.5  974.15  4700.0  972.25  4749.8  970.37  4793.2  965.63
  4828.5  959.67  4834.8  955.61  4842.9  954.99  4849.3  947.64  4857.4  944.24
  4863.7  937.85  4884.5  930.51  4913.5  926.67  4928.0  926.50  4963.5  922.99
  4964.5  922.49  5005.9  922.99  5006.8  925.72  5020.7  925.98  5081.2  930.65
  5098.6  934.95  5126.8  938.66  5133.1  939.75  5241.9  940.50  5362.3  945.62
  5385.3  947.52  5408.2  951.57  5505.6  956.49  5654.4  969.16  5760.5  984.19
#Mann=5,-1,0
  4578.8    0.05       0  4963.5    0.05       0  5005.9    0.05       0
  5020.7    0.12       0  5126.8    0.05       0
Bank Sta=4963.5,5005.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,16595,582,582,582
BEGIN DESCRIPTION:
HONEY CREEK 29.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865955.68     10201753.11      2866613.50     10201600.00
      2866755.69     10201203.10
#Sta/Elev= 30
  4324.6  970.71  4348.5  969.34  4427.3  960.55  4433.6  958.84  4438.8  959.30
  4476.2  955.12  4614.3  947.19  4704.6  940.31  4784.6  936.74  4832.4  932.06
  4917.5  926.68  4965.3  920.53  4971.4  917.61  4986.1  917.18  4987.1  916.68
  5028.6  917.18  5039.2  922.30  5047.7  923.58  5060.4  931.82  5071.1  934.92
  5083.8  946.16  5092.3  950.42  5145.4  959.01  5165.4  958.48  5177.3  959.94
  5227.0  960.28  5241.9  961.72  5319.2  966.34  5367.7  966.27  5421.6  967.74
#Mann=5,-1,0
  4324.6    0.05       0  4986.1    0.07       0  5028.6    0.05       0
  5241.9    0.05       0  5367.7    0.12       0
Bank Sta=4986.1,5028.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,16013,673,673,673
BEGIN DESCRIPTION:
HONEY CREEK 28.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866155.65     10202203.11      2866595.75     10202172.00
      2866905.67     10201903.12
#Sta/Elev= 30
  4558.8  967.99  4631.9  961.24  4767.9  943.61  4829.5  938.93  4879.6  933.52
  4939.8  931.18  4949.8  929.71  4969.9  923.07  4979.9  919.13  4985.0  915.10
  4986.0  914.60  5027.5  915.10  5034.7  917.00  5077.5  916.99  5087.9  918.13
  5098.3  919.20  5105.8  921.60  5112.6  926.10  5119.2  926.08  5126.8  935.64
  5133.5  935.44  5141.1  942.51  5147.7  944.52  5155.3  948.67  5169.6  950.65
  5268.3  955.30  5311.1  956.36  5344.4  959.10  5345.8  959.16  5410.3  962.58
#Mann=6,-1,0
  4558.8    0.05       0  4985.0    0.03       0  5027.5    0.05       0
  5087.9    0.12       0  5344.4    0.05       0  5345.8    0.12       0
Bank Sta=4985,5027.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,15340,451,451,451
BEGIN DESCRIPTION:
Mapping XS 721a1bcd
END DESCRIPTION:
XS GIS Cut Line= 3
      2865999.44     10203072.31      2867023.75     10202725.08
      2867751.84     10202551.73
#Sta/Elev= 30
  4169.9  967.11  4219.1  965.61  4239.8  967.95  4302.7  969.21  4365.6  967.45
  4451.0  960.50  4527.9  951.58  4559.3  945.78  4577.7  948.81  4616.9  948.33
  4725.6  942.31  4788.9  934.11  4836.8  924.92  4862.8  925.51  4915.6  922.30
  4931.0  919.95  4936.7  915.73  4972.3  913.28  4973.3  912.78  5015.3  913.28
  5064.9  919.23  5126.8  926.22  5233.0  929.30  5327.6  932.22  5406.8  939.41
  5411.9  938.02  5454.1  944.33  5746.9  954.87  5933.1  970.17  5999.9  970.86
#Mann=5,-1,0
  4169.9    0.05       0  4972.3    0.05       0  5015.3    0.05       0
  5064.9    0.12       0  5233.0    0.05       0
Bank Sta=4972.3,5015.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,14889,601,601,601
BEGIN DESCRIPTION:
Mapping XS 95da567c
END DESCRIPTION:
XS GIS Cut Line= 2
      2866364.03     10203506.33      2867491.63     10202933.86
#Sta/Elev= 30
  4413.8  953.68  4493.4  951.15  4499.0  952.40  4515.7  951.74  4521.3  953.77
  4527.8  952.20  4588.0  948.91  4604.7  946.45  4662.4  944.93  4721.6  939.20
  4738.3  934.89  4766.1  930.95  4805.0  930.35  4841.8  927.88  4899.7  919.40
  4999.7  910.23  5000.7  909.73  5042.8  910.23  5043.7  912.72  5055.5  912.30
  5077.8  919.44  5128.5  922.29  5183.5  924.30  5265.7  930.24  5289.1  933.79
  5301.6  934.19  5324.1  938.26  5400.4  944.51  5556.3  942.38  5678.4  945.32
#Mann=5,-1,0
  4413.8    0.05       0  4999.7    0.03       0  5042.8    0.05       0
  5128.5    0.12       0  5265.7    0.05       0
Bank Sta=4999.7,5042.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,14288,558,558,558
BEGIN DESCRIPTION:
HONEY CREEK 25.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866405.69     10204253.11      2867091.25     10203787.00
      2867505.67     10203753.11
#Sta/Elev= 30
  4171.0  985.86  4214.4  979.39  4220.4  980.78  4243.5  976.60  4280.2  974.66
  4316.1  970.93  4343.1  965.58  4423.9  957.95  4429.9  954.82  4459.8  949.84
  4567.6  942.12  4588.6  947.45  4594.6  947.18  4609.5  945.95  4624.5  939.90
  4717.3  935.36  4811.9  925.95  4890.9  914.61  4911.9  915.89  4947.8  908.02
  4969.1  909.94  4983.1  907.98  4984.1  907.48  5026.3  907.98  5034.5  910.70
  5082.1  914.17  5225.2  924.14  5295.4  937.52  5332.6  942.06  5415.8  952.12
#Mann=6,-1,0
  4171.0    0.12       0  4280.2    0.05       0  4983.1    0.05       0
  5026.3    0.05       0  5082.1    0.12       0  5332.6    0.05       0
Bank Sta=4983.1,5026.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,13730,588,588,588
BEGIN DESCRIPTION:
HONEY CREEK 24.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866855.66     10204453.12      2867249.25     10204310.00
      2867655.72     10204403.12
#Sta/Elev= 30
  4581.2  946.68  4627.1  943.38  4666.3  937.20  4683.0  936.35  4688.3  934.70
  4744.2  928.02  4794.0  923.77  4830.6  916.55  4855.9  906.69  4879.2  904.11
  4911.1  902.95  4931.7  900.15  4942.3  895.42  4942.7  894.19  4943.7  893.69
  4985.9  894.19  4995.4  896.06  5016.9  895.31  5039.4  898.82  5047.6  901.55
  5057.9  916.22  5068.2  918.65  5077.2  922.75  5082.3  922.07  5088.7  925.22
  5191.2  934.16  5242.6  938.42  5283.6  944.13  5344.9  948.37  5417.0  956.16
#Mann=5,-1,0
  4581.2    0.05       0  4931.7    0.12       0  4942.7    0.07       0
  4985.9    0.12       0  5191.2    0.05       0
Bank Sta=4942.7,4985.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,13142,584,584,584
BEGIN DESCRIPTION:
HONEY CREEK 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866705.69     10204753.11      2867201.25     10204894.00
      2867705.67     10204553.12
#Sta/Elev= 30
  4484.8  964.79  4506.9  963.60  4547.2  953.66  4588.8  949.19  4703.1  940.95
  4720.6  936.76  4793.6  925.17  4832.6  920.39  4866.5  911.93  4871.7  912.53
  4879.9  909.17  4900.4  904.18  4905.6  904.56  4911.0  902.54  4944.7  898.95
  4972.6  892.43  4973.6  891.93  5015.8  892.43  5017.4  893.56  5032.0  893.10
  5053.6  894.70  5061.6  896.62  5103.9  899.01  5126.0  901.72  5190.8  903.87
  5220.7  913.29  5226.7  913.17  5242.0  919.48  5493.4  943.22  5608.8  958.38
#Mann=5,-1,0
  4484.8    0.05       0  4972.6    0.05       0  5015.8    0.05       0
  5061.6    0.12       0  5242.0    0.05       0
Bank Sta=4972.6,5015.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12558,565,565,565
BEGIN DESCRIPTION:
HONEY CREEK 22.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866855.66     10205203.09      2867153.00     10205472.00
      2867955.68     10205153.11
#Sta/Elev= 30
  4599.1  950.15  4726.5  941.29  4769.1  933.98  4783.3  933.20  4790.1  935.45
  4797.5  930.94  4804.3  932.37  4825.9  926.40  4832.6  927.81  4846.8  922.58
  4854.3  917.20  4861.0  917.92  4868.5  913.07  4875.2  913.41  4889.4  905.33
  4903.1  902.28  4910.4  903.05  4974.6  890.53  5002.8  889.74  5003.8  889.24
  5046.0  889.74  5147.1  894.10  5250.1  905.56  5328.3  910.62  5368.7  914.28
  5392.7  913.40  5662.6  934.31  5824.6  951.36  5850.5  956.39  5863.7  957.85
#Mann=7,-1,0
  4599.1    0.12       0  4903.1    0.05       0  5002.8    0.05       0
  5046.0    0.05       0  5250.1    0.12       0  5328.3    0.05       0
  5850.5    0.12       0
Bank Sta=5002.8,5046
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11993,587,587,587
BEGIN DESCRIPTION:
HONEY CREEK 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867105.68     10206453.13      2867217.25     10206021.00
      2867901.73     10205615.27
#Sta/Elev= 30
  4553.7  947.02  4571.5  945.35  4576.6  942.60  4595.0  943.46  4652.8  938.90
  4676.5  935.77  4749.9  923.35  4769.6  921.44  4842.9  908.02  4863.6  901.21
  4891.6  894.82  4896.7  891.05  4915.2  889.73  4937.4  884.66  4966.8  883.06
  4971.1  879.61  4972.1  879.11  5021.6  879.61  5026.3  883.48  5033.1  884.33
  5069.1  885.48  5091.2  884.59  5121.8  891.46  5149.3  892.03  5185.8  896.24
  5378.4  908.66  5382.6  908.91  5539.2  918.43  5616.9  921.92  5795.7  932.97
#Mann=8,-1,0
  4553.7    0.12       0  4676.5    0.05       0  4971.1    0.03       0
  5021.6    0.05       0  5185.8    0.12       0  5378.4    0.05       0
  5382.6    0.12       0  5539.2    0.05       0
Bank Sta=4971.1,5021.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11406,521,521,521
BEGIN DESCRIPTION:
HONEY CREEK 20.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867255.67     10206653.12      2867615.75     10206443.00
      2868076.43     10205892.41
#Sta/Elev= 30
  4583.1  957.22  4649.7  948.07  4671.2  943.32  4692.7  940.97  4708.4  935.65
  4751.4  925.67  4794.4  918.28  4810.1  913.40  4831.6  908.64  4861.0  900.39
  4896.1  887.19  4911.8  885.94  4949.0  880.28  4964.7  879.55  4966.7  877.62
  4967.7  877.12  5017.2  877.62  5021.3  880.27  5058.1  883.36  5085.1  889.09
  5134.6  893.90  5169.7  901.21  5284.2  909.10  5290.7  908.49  5342.6  911.05
  5567.9  923.17  5596.5  924.10  5617.3  923.27  5660.3  925.08  5717.9  924.38
#Mann=5,-1,0
  4583.1    0.05       0  4966.7    0.03       0  5017.2    0.05       0
  5058.1    0.12       0  5342.6    0.05       0
Bank Sta=4966.7,5017.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10885,541,541,541
BEGIN DESCRIPTION:
Mapping XS 4cf1cb51
END DESCRIPTION:
XS GIS Cut Line= 3
      2867720.56     10207289.94      2868137.22     10206560.79
      2868354.22     10205779.57
#Sta/Elev= 30
  4374.6  965.63  4434.8  963.60  4574.5  949.65  4589.8  947.30  4601.8  942.86
  4676.7  932.51  4751.0  919.60  4763.1  915.61  4831.6  903.14  4859.5  893.42
  4902.7  884.81  4973.9  876.36  4974.9  875.86  5024.5  876.36  5027.4  878.68
  5037.0  879.02  5123.0  887.09  5197.8  899.40  5254.2  903.08  5461.1  911.96
  5561.7  913.10  5601.1  907.60  5640.5  906.06  5668.7  908.89  5689.4  907.66
  5720.5  910.56  5787.9  911.80  5907.4  921.52  5940.5  920.69  6025.2  923.64
#Mann=5,-1,0
  4374.6    0.05       0  4973.9    0.03       0  5024.5    0.05       0
  5037.0    0.12       0  5254.2    0.05       0
Bank Sta=4973.9,5024.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10344,584,584,584
BEGIN DESCRIPTION:
HONEY CREEK 18.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868355.67     10207653.15      2868549.25     10206876.00
      2868805.67     10206553.13
#Sta/Elev= 30
  4199.1  946.44  4240.7  941.77  4312.5  930.25  4340.9  927.49  4498.0  911.95
  4547.6  910.53  4642.3  902.44  4712.8  898.85  4741.8  894.97  4776.3  886.75
  4827.8  881.76  4840.8  881.88  4859.6  880.91  4889.6  878.86  4905.4  874.20
  4906.4  873.70  4956.2  874.20  4960.6  876.79  5006.2  875.76  5049.5  881.92
  5092.7  880.27  5099.1  881.80  5113.5  881.85  5119.9  884.01  5203.7  887.33
  5241.7  888.84  5256.1  891.90  5262.5  894.78  5334.6  906.11  5412.3  910.79
#Mann=9,-1,0
  4199.1    0.05       0  4240.7    0.12       0  4340.9    0.05       0
  4741.8    0.12       0  4840.8    0.05       0  4859.6    0.12       0
  4905.4    0.07       0  4956.2    0.12       0  5203.7    0.05       0
Bank Sta=4905.4,4956.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9760,578,578,578
BEGIN DESCRIPTION:
HONEY CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868955.67     10207353.14      2869106.50     10206979.00
      2869155.68     10206553.13
#Sta/Elev= 30
  4596.6  907.02  4665.1  902.45  4712.5  896.93  4736.8  894.33  4790.7  886.22
  4796.7  884.11  4815.5  881.85  4850.4  879.12  4909.5  876.70  4920.1  875.94
  4928.2  873.00  4933.6  873.95  4957.8  872.82  4961.9  871.62  4962.9  871.12
  5012.8  871.62  5022.5  872.78  5038.8  872.53  5066.3  876.49  5096.5  875.99
  5116.7  877.99  5122.7  879.76  5127.7  880.01  5146.9  885.59  5177.1  889.77
  5217.3  898.40  5277.7  906.17  5317.8  908.67  5416.3  913.93  5428.7  914.78
#Mann=8,-1,0
  4596.6    0.05       0  4712.5    0.12       0  4815.5    0.05       0
  4961.9    0.05       0  5012.8    0.05       0  5022.5    0.12       0
  5317.8    0.05       0  5416.3    0.12       0
Bank Sta=4961.9,5012.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9182,538,538,538
BEGIN DESCRIPTION:
HONEY CREEK 16.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2869205.70     10207753.09      2869672.25     10206942.00
      2869355.71     10206603.14
#Sta/Elev= 30
  4064.3  938.29  4115.3  933.98  4137.5  929.94  4174.2  924.67  4195.8  925.42
  4292.1  913.23  4421.9  904.77  4517.7  894.12  4796.6  874.08  4883.4  872.42
  4898.6  870.48  4903.9  868.11  4904.9  867.61  4955.0  868.11  4964.1  870.12
  4994.9  868.46  5053.2  868.81  5084.9  876.32  5088.8  878.09  5095.7  877.29
  5103.0  880.51  5109.8  879.01  5117.1  882.65  5124.0  881.99  5131.3  884.35
  5225.0  892.38  5265.7  894.09  5322.3  900.46  5415.5  903.55  5463.7  906.77
#Mann=7,-1,0
  4064.3    0.12       0  4137.5    0.05       0  4903.9    0.05       0
  4955.0    0.05       0  5084.9    0.12       0  5225.0    0.05       0
  5415.5    0.12       0
Bank Sta=4903.9,4955
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8644,513,513,513
BEGIN DESCRIPTION:
Mapping XS 8044d41d
END DESCRIPTION:
XS GIS Cut Line= 2
      2870281.32     10207593.80      2870125.17     10206327.29
#Sta/Elev= 30
  4261.6  908.65  4393.3  901.61  4554.5  897.69  4604.9  891.72  4665.3  892.40
  4685.5  890.83  4725.8  890.48  4816.5  879.49  4840.2  873.62  4856.8  872.65
  4876.9  869.20  4921.4  865.77  4947.4  860.47  4952.1  855.94  4953.1  855.44
  5003.3  855.94  5038.1  857.07  5068.3  869.16  5083.7  873.36  5199.3  882.59
  5229.6  887.33  5246.1  892.38  5310.2  899.69  5332.3  903.60  5370.6  903.63
  5390.8  905.17  5400.8  904.25  5413.4  906.09  5451.2  903.85  5537.7  915.41
#Mann=3,-1,0
  4261.6    0.05       0  4952.1    0.03       0  5003.3    0.12       0
Bank Sta=4952.1,5003.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8131,482,482,482
BEGIN DESCRIPTION:
HONEY CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2870555.68     10207103.12      2870681.50     10206717.00
      2870855.67     10206353.14
#Sta/Elev= 30
  4593.9  900.93  4667.5  897.93  4699.1  894.47  4730.6  887.41  4737.5  883.78
  4742.8  884.52  4766.7  875.82  4769.4  874.30  4774.7  875.60  4801.4  865.43
  5001.0  855.13  5002.0  854.63  5052.2  855.13  5059.7  859.66  5072.0  859.94
  5089.1  864.25  5134.4  871.20  5140.0  870.53  5162.7  875.57  5179.8  881.73
  5208.0  887.15  5230.7  895.17  5237.1  899.42  5253.3  903.62  5259.3  907.54
  5281.5  915.96  5304.2  919.93  5326.9  928.66  5349.5  933.25  5403.4  938.42
#Mann=4,-1,0
  4593.9    0.05       0  4766.7    0.12       0  5001.0    0.07       0
  5052.2    0.12       0
Bank Sta=5001,5052.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7649,597,597,597
BEGIN DESCRIPTION:
Mapping XS 268ae368
END DESCRIPTION:
XS GIS Cut Line= 2
      2870880.27     10207637.18      2871200.60     10206407.82
#Sta/Elev= 30
  4196.6  908.62  4283.5  908.91  4345.5  904.47  4366.1  900.31  4459.1  894.98
  4521.1  886.60  4541.8  886.18  4551.1  882.38  4596.7  875.26  4624.5  880.20
  4727.8  883.68  4950.9  859.28  4986.2  849.01  5001.1  847.66  5002.1  847.16
  5052.3  847.66  5062.2  851.62  5079.2  852.89  5107.7  868.79  5112.9  873.62
  5148.2  881.78  5153.4  889.63  5188.7  903.61  5269.7  904.70  5285.9  911.73
  5296.2  913.35  5386.0  921.32  5399.5  919.21  5420.2  921.08  5467.0  919.01
#Mann=4,-1,0
  4196.6    0.05       0  5001.1    0.05       0  5052.3    0.05       0
  5062.2    0.12       0
Bank Sta=5001.1,5052.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7052,588,588,588
BEGIN DESCRIPTION:
HONEY CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2871405.67     10207703.15      2871603.25     10207140.00
      2871855.70     10206803.09
#Sta/Elev= 30
  4403.2  918.90  4435.0  907.20  4466.8  899.19  4498.6  895.65  4537.4  887.17
  4594.0  881.01  4647.0  871.08  4656.1  867.61  4661.5  868.23  4678.8  863.74
  4700.0  862.19  4742.4  867.83  4763.6  867.40  4827.1  860.22  4890.7  856.67
  4922.5  851.11  4970.5  846.79  4971.5  846.29  5021.8  846.79  5028.2  854.36
  5057.4  861.89  5063.6  865.46  5078.2  880.88  5099.1  887.83  5128.2  890.98
  5178.2  892.62  5242.8  901.53  5292.8  910.99  5392.8  923.25  5421.0  924.78
#Mann=4,-1,0
  4403.2    0.05       0  4661.5    0.12       0  4970.5    0.07       0
  5021.8    0.12       0
Bank Sta=4970.5,5021.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6464,1167,1167,1167
BEGIN DESCRIPTION:
HONEY CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872055.68     10207953.11      2872047.00     10207522.00
      2872055.68     10207103.09
#Sta/Elev= 30
  4568.8  905.39  4608.8  900.59  4628.8  897.28  4638.8  895.46  4653.4  891.13
  4678.8  883.67  4698.8  880.00  4738.8  867.50  4751.8  865.49  4778.8  861.80
  4815.5  858.40  4820.5  858.96  4948.9  851.30  4968.9  848.80  4971.2  845.92
  4972.2  845.42  5022.6  845.92  5028.9  847.29  5058.9  846.20  5078.9  848.49
  5088.9  850.87  5108.9  858.28  5138.9  872.67  5158.9  877.66  5175.8  880.74
  5180.8  880.27  5198.9  883.92  5268.9  890.23  5359.0  900.90  5419.0  904.85
#Mann=5,-1,0
  4568.8    0.12       0  4653.4    0.05       0  4751.8    0.12       0
  4971.2    0.07       0  5022.6    0.12       0
Bank Sta=4971.2,5022.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5297,586,586,586
BEGIN DESCRIPTION:
HONEY CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872855.67     10208503.13      2873030.50     10208124.00
      2873555.69     10207353.10
#Sta/Elev= 30
  4582.5  925.80  4619.7  921.54  4681.6  908.76  4711.5  898.01  4733.9  895.76
  4780.1  890.47  4877.7  871.38  4906.1  875.01  4923.6  861.60  4929.1  862.86
  4934.9  854.05  4957.6  844.73  4964.3  837.20  4965.3  836.70  5015.7  837.20
  5264.0  860.14  5350.7  863.92  5443.5  864.19  5644.1  848.51  5673.9  855.78
  5730.8  857.05  5751.8  860.29  5817.6  882.57  5847.4  898.44  5853.5  898.51
  5868.4  909.12  5889.4  916.24  5904.3  927.20  5925.3  932.50  5932.8  938.30
#Mann=5,-1,0
  4582.5    0.12       0  4733.9    0.05       0  4780.1    0.12       0
  4964.3    0.07       0  5015.7    0.12       0
Bank Sta=4964.3,5015.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4711,584,584,584
BEGIN DESCRIPTION:
HONEY CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2873455.69     10208453.09      2873604.75     10208072.00
      2873605.68     10207303.10
#Sta/Elev= 30
  4590.8  904.45  4626.1  898.42  4665.9  884.14  4684.5  882.91  4689.8  878.61
  4714.3  876.20  4719.7  872.39  4738.7  870.41  4768.6  862.66  4773.9  866.71
  4793.0  866.77  4798.4  870.67  4847.3  858.94  4852.7  860.23  4923.6  838.15
  4971.0  836.10  4972.0  835.60  5022.4  836.10  5148.9  849.33  5188.9  859.45
  5235.5  862.33  5308.9  862.24  5432.1  854.26  5498.9  843.66  5528.9  847.36
  5578.9  865.54  5648.9  897.09  5738.9  943.98  5758.9  949.37  5768.9  949.04
#Mann=6,-1,0
  4590.8    0.05       0  4626.1    0.12       0  4971.0    0.07       0
  5022.4    0.12       0  5235.5    0.05       0  5432.1    0.12       0
Bank Sta=4971,5022.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4127,587,587,587
BEGIN DESCRIPTION:
HONEY CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2873905.67     10208303.13      2874172.25     10207976.00
      2874005.69     10207553.12
#Sta/Elev= 30
  4578.0  876.21  4741.3  870.80  4876.0  861.65  4904.8  856.31  4912.7  852.22
  4919.1  852.52  4933.5  843.78  4947.9  838.15  4954.3  839.04  4962.2  835.67
  5000.0  832.96  5024.6  835.64  5060.5  834.77  5064.4  832.93  5065.4  832.43
  5116.1  832.93  5121.3  838.60  5144.5  838.92  5207.3  848.81  5325.5  851.39
  5355.7  860.68  5361.1  860.27  5379.3  872.59  5385.5  879.44  5390.8  879.16
  5409.9  893.52  5415.2  893.32  5439.6  903.58  5445.0  900.28  5454.5  901.35
#Mann=4,-1,0
  4578.0    0.05       0  4741.3    0.12       0  5064.4    0.07       0
  5116.1    0.12       0
Bank Sta=5064.4,5116.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3540,556,556,556
BEGIN DESCRIPTION:
HONEY CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2874455.66     10208553.15      2874698.50     10208093.00
      2875005.71     10207803.09
#Sta/Elev= 30
  4479.7  864.77  4493.6  862.77  4518.7  855.50  4537.6  851.50  4592.4  850.13
  4686.1  844.93  4702.5  838.84  4717.2  836.74  4730.2  838.54  4746.5  844.76
  4762.4  845.19  4768.5  847.46  4841.6  846.73  4873.0  844.26  4939.0  835.81
  4966.7  830.76  4971.2  827.61  4972.2  827.11  5023.0  827.61  5033.4  840.48
  5040.3  843.05  5047.5  850.59  5054.4  850.89  5061.7  854.43  5075.9  856.60
  5118.3  861.71  5174.9  864.42  5266.8  872.34  5358.7  882.90  5422.4  888.38
#Mann=4,-1,0
  4479.7    0.05       0  4518.7    0.12       0  4971.2    0.07       0
  5023.0    0.12       0
Bank Sta=4971.2,5023
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2984,552,552,552
BEGIN DESCRIPTION:
HONEY CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2874605.71     10208753.10      2874970.25     10208567.00
      2875305.69     10208303.11
#Sta/Elev= 30
  4590.7  866.33  4599.0  865.91  4613.1  862.89  4629.9  856.63  4643.4  851.68
  4680.5  847.05  4799.9  843.59  4837.7  842.36  4864.7  843.22  4910.1  841.30
  4932.3  836.80  4961.2  827.35  4968.3  827.51  4972.9  826.74  4973.9  826.24
  5024.7  826.74  5028.3  834.43  5034.6  835.38  5042.7  841.11  5049.1  838.78
  5057.2  843.48  5070.5  844.87  5078.0  847.07  5098.8  849.07  5106.9  851.01
  5177.4  853.30  5191.8  854.79  5253.8  857.97  5355.4  863.39  5426.8  871.53
#Mann=8,-1,0
  4590.7    0.05       0  4629.9    0.12       0  4799.9    0.05       0
  4864.7    0.12       0  4968.3    0.05       0  4972.9    0.07       0
  5024.7    0.05       0  5253.8    0.05       0
Bank Sta=4972.9,5024.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2432,577,577,577
BEGIN DESCRIPTION:
HONEY CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2874755.64     10208953.10      2875142.00     10209090.00
      2875505.69     10208903.11
#Sta/Elev= 30
  4590.1  865.42  4600.3  863.72  4605.6  865.82  4631.2  852.73  4636.5  854.57
  4643.2  850.72  4662.1  843.45  4667.4  844.56  4677.8  841.97  4692.9  840.41
  4717.5  840.42  4754.7  839.04  4822.2  839.08  4878.2  839.49  4934.7  837.30
  4960.3  832.65  4965.6  832.78  4972.1  830.50  4973.4  825.62  4974.4  825.12
  5025.3  825.62  5037.9  831.79  5045.7  837.30  5047.2  837.68  5051.3  838.73
  5060.4  844.88  5067.9  848.24  5134.4  849.27  5174.9  850.78  5408.9  861.41
#Mann=7,-1,0
  4590.1    0.05       0  4677.8    0.12       0  4822.2    0.05       0
  4973.4    0.05       0  5025.3    0.05       0  5047.2    0.12       0
  5174.9    0.05       0
Bank Sta=4973.4,5025.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1855,334,334,334
BEGIN DESCRIPTION:
HONEY CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2874805.72     10209703.11      2875204.00     10209661.00
      2875555.69     10209003.10
#Sta/Elev= 30
  4599.5  865.03  4609.5  864.97  4645.9  860.17  4690.0  858.25  4790.5  856.85
  4921.2  856.69  4929.3  854.99  4934.3  849.87  4941.4  844.66  4964.2  832.91
  4971.5  829.80  4988.4  826.44  4989.4  825.94  5040.3  826.44  5052.6  827.41
  5058.3  829.97  5074.6  830.46  5080.2  831.75  5162.3  835.11  5213.0  839.11
  5282.1  840.21  5312.9  838.42  5348.5  839.26  5376.1  838.25  5421.9  840.54
  5436.3  843.24  5442.0  843.38  5458.2  848.70  5621.3  853.28  5746.0  860.47
#Mann=7,-1,0
  4599.5    0.05       0  4964.2    0.12       0  4988.4    0.07       0
  5040.3    0.12       0  5282.1    0.05       0  5312.9    0.12       0
  5421.9    0.05       0
Bank Sta=4988.4,5040.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1521,709,709,709
BEGIN DESCRIPTION:
Mapping XS f89d7993
END DESCRIPTION:
XS GIS Cut Line= 3
      2875382.53     10209994.61      2875408.14     10209807.43
      2875668.27     10209070.41
#Sta/Elev= 30
  4918.3  857.20  4950.1  857.54  4960.2  847.49  4976.9  825.99  4984.7  825.76
  4985.7  825.26  5036.6  825.76  5049.1  829.25  5101.5  833.49  5146.9  834.19
  5186.0  833.00  5260.0  835.09  5291.0  834.78  5302.7  836.56  5327.2  837.13
  5366.3  840.03  5376.9  839.84  5383.7  841.18  5398.1  841.80  5445.6  842.45
  5525.4  836.85  5546.0  838.27  5564.0  840.41  5578.4  845.00  5589.0  844.64
  5595.0  847.86  5600.3  849.14  5648.6  851.05  5854.1  855.24  5888.8  856.74
#Mann=5,-1,0
  4918.3    0.05       0  4984.7    0.05       0  5036.6    0.05       0
  5546.0    0.12       0  5648.6    0.05       0
Bank Sta=4984.7,5036.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,812,327,327,327
BEGIN DESCRIPTION:
HONEY CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875922.50     10210304.02      2876044.68     10209752.25
      2875885.04     10209293.04
#Sta/Elev= 30
  4225.9  855.69  4237.1  855.11  4278.0  846.87  4319.0  841.86  4380.5  839.67
  4435.7  840.53  4472.6  840.27  4482.9  839.14  4535.4  839.91  4635.1  838.92
  4676.2  834.57  4773.7  835.49  4779.9  833.82  4793.2  833.55  4804.6  835.44
  4837.1  834.92  4929.0  834.08  4938.3  832.81  4948.9  828.20  4960.0  825.57
  4961.0  825.07  5011.9  825.57  5033.6  826.89  5048.3  830.66  5054.8  837.20
  5074.0  848.80  5079.3  847.49  5086.6  851.78  5110.4  855.30  5277.2  855.68
#Mann=8,-1,0
  4225.9    0.05       0  4435.7    0.12       0  4535.4     0.1       0
  4635.1    0.05       0  4837.1    0.12       0  4960.0    0.07       0
  5011.9    0.12       0  5048.3    0.05       0
Bank Sta=4960,5011.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,485,0,0,0
BEGIN DESCRIPTION:
HONEY CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 4
      2876202.29     10210586.90      2876359.99     10209752.25
      2876247.66     10209334.46      2875955.99     10209204.39
#Sta/Elev= 30
  3806.8  849.48  3871.7  842.20  3973.5  839.57  3991.4  837.97  4044.7  840.25
  4090.6  839.97  4156.7  841.30  4278.3  840.32  4360.2  836.39  4421.3  837.66
  4445.6  839.99  4451.8  838.82  4733.0  840.62  4872.8  839.90  4903.8  837.56
  4914.2  835.48  4921.3  829.81  4934.9  826.11  4991.8  825.54  4992.8  825.04
  5043.7  825.54  5048.8  832.83  5059.2  839.10  5069.5  843.05  5075.9  843.84
  5081.1  846.92  5100.5  848.85  5204.3  848.80  5274.0  852.45  5408.2  854.56
#Mann=6,-1,0
  3806.8    0.05       0  3991.4    0.12       0  4090.6    0.05       0
  4733.0    0.05       0  4991.8    0.05       0  5043.7    0.05       0
Bank Sta=4991.8,5043.7
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
