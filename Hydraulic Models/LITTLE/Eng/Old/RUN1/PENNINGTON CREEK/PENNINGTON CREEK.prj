HEC-RAS study PENNINGTON CREEK.prj: PENNINGTON CREEK Base Level Engineering

--- PENNINGTON CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,13434,492,492,492
BEGIN DESCRIPTION:
PENNINGTON CREEK 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2870605.68     10233553.11      2870477.75     10233309.00
      2870055.66     10232903.09
#Sta/Elev= 30
  4724.4  933.97  4839.9  928.98  4859.3  927.95  4865.0  926.50  4887.0  925.25
  4903.5  925.20  4931.2  922.02  4953.2  921.80  4969.6  919.47  4975.3  919.99
  4991.4  918.68  4991.9  915.68  5001.8  915.68  5002.3  918.68  5005.5  920.17
  5012.8  920.63  5019.7  922.53  5026.9  921.50  5033.8  924.13  5041.1  923.83
  5048.0  925.10  5055.2  925.41  5161.2  924.75  5203.6  923.04  5246.1  924.97
  5281.3  928.41  5316.8  927.25  5380.4  928.12  5444.2  929.40  5585.6  933.76
#Mann=5,-1,0
  4724.4    0.05       0  4839.9    0.12       0  4865.0    0.05       0
  4991.4    0.05       0  5002.3    0.05       0
Bank Sta=4991.4,5002.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12942,480,480,480
BEGIN DESCRIPTION:
PENNINGTON CREEK 22.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2870855.70     10232853.11      2870568.75     10232922.00
      2870155.66     10232703.10
#Sta/Elev= 30
  4704.9  932.61  4781.8  929.33  4801.6  928.33  4854.4  926.03  4904.2  925.32
  4943.5  924.09  4962.0  922.93  4980.4  918.68  4985.5  918.78  4992.9  917.60
  5025.2  917.16  5025.7  914.16  5035.8  914.16  5036.3  917.16  5037.4  918.64
  5047.0  921.43  5060.1  921.81  5135.0  921.35  5173.2  920.50  5179.0  920.91
  5245.0  921.65  5267.0  923.24  5275.1  924.54  5305.3  926.39  5311.0  926.19
  5377.0  931.52  5393.3  931.98  5399.6  932.92  5444.8  934.34  5467.5  935.61
#Mann=6,-1,0
  4704.9    0.12       0  4781.8    0.05       0  4801.6    0.12       0
  4904.2    0.05       0  5025.2    0.03       0  5036.3    0.05       0
Bank Sta=5025.2,5036.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12462,434,434,434
BEGIN DESCRIPTION:
PENNINGTON CREEK 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2870905.71     10232453.11      2870614.25     10232444.00
      2870405.72     10232403.12
#Sta/Elev= 30
  4708.4  949.26  4718.4  948.39  4728.4  943.45  4748.4  937.69  4778.5  931.12
  4788.5  929.52  4866.0  923.93  4871.0  924.22  4878.5  923.21  4918.5  921.55
  4938.5  917.09  4948.5  913.95  4958.5  914.79  4988.6  915.22  4991.2  913.94
  4991.7  910.94  5001.8  910.94  5002.3  913.94  5018.9  915.95  5032.4  915.25
  5059.7  915.33  5078.8  917.96  5100.4  919.22  5120.8  917.67  5151.4  917.98
  5181.7  921.11  5186.8  922.58  5192.2  925.75  5210.0  930.72  5212.5  930.72
#Mann=3,-1,0
  4708.4    0.05       0  4991.2    0.05       0  5002.3    0.05       0
Bank Sta=4991.2,5002.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12028,454,454,454
BEGIN DESCRIPTION:
PENNINGTON CREEK 20.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2870905.65     10232053.11      2870690.25     10232026.00
      2870505.66     10232003.11
#Sta/Elev= 30
  4782.9  928.80  4792.9  930.04  4803.0  929.49  4813.1  926.48  4820.5  922.92
  4825.6  919.46  4843.3  916.15  4853.4  914.94  4883.7  912.93  4900.9  913.91
  4905.9  917.11  4913.9  918.07  4944.1  917.41  4964.3  916.06  4974.4  913.55
  4975.6  910.27  4976.1  907.27  4986.3  907.27  4986.8  910.27  5014.7  912.44
  5034.8  913.25  5062.1  920.92  5067.1  920.76  5105.4  924.17  5135.6  925.79
  5143.0  926.77  5148.0  926.22  5165.8  927.78  5175.9  928.06  5186.0  929.26
#Mann=3,-1,0
  4782.9    0.05       0  4975.6    0.05       0  4986.8    0.05       0
Bank Sta=4975.6,4986.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11574,426,426,426
BEGIN DESCRIPTION:
PENNINGTON CREEK 19.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2871105.68     10231903.11      2870827.00     10231596.00
      2870405.70     10231353.12
#Sta/Elev= 30
  4585.3  929.37  4588.7  929.37  4599.1  925.34  4606.6  923.43  4613.3  922.41
  4641.7  920.64  4677.5  920.39  4698.5  919.10  4741.1  918.94  4783.6  917.19
  4812.0  914.99  4840.4  915.70  4903.9  915.03  4918.1  916.21  4924.9  915.88
  4953.3  911.39  4989.1  909.89  4989.8  909.06  4990.3  906.06  5001.4  906.06
  5001.9  909.06  5017.3  910.31  5037.5  913.74  5047.7  915.68  5054.6  916.17
  5142.8  915.75  5280.2  918.13  5376.4  922.12  5441.1  926.58  5486.3  928.81
#Mann=5,-1,0
  4585.3    0.05       0  4989.8    0.05       0  5001.9    0.05       0
  5037.5    0.12       0  5142.8    0.05       0
Bank Sta=4989.8,5001.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11148,496,496,496
BEGIN DESCRIPTION:
PENNINGTON CREEK 18.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2871455.69     10231653.11      2871068.50     10231252.00
      2870955.67     10231003.08
#Sta/Elev= 30
  4442.5  930.08  4456.5  928.94  4470.7  930.50  4477.9  928.89  4548.6  924.43
  4583.9  923.32  4591.1  922.07  4605.2  921.20  4690.1  917.16  4786.7  914.99
  4863.5  914.73  4902.1  915.19  4951.7  912.42  4972.8  912.97  4998.4  909.27
  5062.7  908.83  5063.2  905.83  5074.4  905.83  5074.9  908.83  5086.4  910.28
  5091.9  912.73  5097.6  913.26  5108.6  913.13  5114.9  912.05  5120.4  912.98
  5161.1  914.53  5184.2  917.22  5207.3  922.78  5218.4  923.97  5273.3  926.49
#Mann=5,-1,0
  4442.5    0.05       0  4786.7    0.12       0  4863.5    0.05       0
  5062.7    0.05       0  5074.9    0.05       0
Bank Sta=5062.7,5074.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10652,473,473,473
BEGIN DESCRIPTION:
PENNINGTON CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2871755.66     10231103.11      2871359.25     10230975.00
      2871055.64     10230953.11
#Sta/Elev= 30
  4583.4  921.83  4593.9  921.77  4636.7  918.82  4700.7  916.85  4741.0  914.56
  4759.5  915.21  4764.8  914.53  4791.5  914.66  4930.2  911.52  4951.2  911.60
  4956.9  911.32  4972.2  906.79  5007.5  905.75  5008.0  902.75  5019.2  902.75
  5019.7  905.75  5033.7  908.10  5043.7  907.32  5063.7  910.25  5092.3  912.00
  5154.0  912.39  5184.0  913.53  5204.1  912.84  5224.1  910.28  5232.0  910.30
  5237.0  911.77  5254.2  920.63  5264.2  922.61  5274.3  923.53  5304.4  924.49
#Mann=3,-1,0
  4583.4    0.05       0  5007.5    0.05       0  5019.7    0.05       0
Bank Sta=5007.5,5019.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10179,475,475,475
BEGIN DESCRIPTION:
PENNINGTON CREEK 16.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2871905.66     10230753.10      2871659.00     10230616.00
      2871355.67     10230453.11
#Sta/Elev= 30
  4717.8  920.93  4769.2  918.83  4828.7  914.07  4872.2  911.76  4909.9  908.15
  4931.7  904.81  4937.4  905.48  4959.1  904.75  4969.4  906.04  4980.9  905.53
  4985.0  903.70  4985.5  900.70  4996.8  900.70  4997.3  903.70  5013.1  905.06
  5040.7  909.33  5056.9  910.19  5078.8  909.69  5106.4  910.77  5182.7  911.09
  5188.4  910.63  5204.7  912.39  5219.4  912.19  5226.6  913.22  5232.2  912.94
  5248.5  914.21  5276.2  915.09  5292.3  916.49  5298.9  917.70  5344.3  921.15
#Mann=3,-1,0
  4717.8    0.05       0  4985.0    0.05       0  4997.3    0.05       0
Bank Sta=4985,4997.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9704,475,475,475
BEGIN DESCRIPTION:
PENNINGTON CREEK 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872155.69     10230553.12      2871915.50     10230219.00
      2871505.66     10230153.11
#Sta/Elev= 30
  4588.5  922.67  4625.3  919.22  4637.8  919.09  4688.0  912.90  4696.5  913.89
  4724.0  912.04  4753.0  911.92  4767.7  914.13  4797.2  915.61  4904.0  911.59
  4910.2  908.41  4918.7  906.90  4924.9  904.10  4939.6  904.61  4945.8  903.12
  4962.9  902.23  4963.4  899.23  4974.7  899.23  4975.2  902.23  5020.1  903.19
  5040.3  907.02  5067.1  908.55  5080.8  907.74  5196.0  908.12  5293.5  910.28
  5324.8  912.55  5354.3  917.03  5374.6  917.29  5394.8  919.34  5415.1  919.27
#Mann=3,-1,0
  4588.5    0.05       0  4962.9    0.03       0  4975.2    0.05       0
Bank Sta=4962.9,4975.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9229,487,487,487
BEGIN DESCRIPTION:
PENNINGTON CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872405.66     10229803.11      2872106.00     10229791.00
      2871355.72     10229353.13
#Sta/Elev= 30
  4700.1  917.78  4730.1  917.01  4850.2  906.79  4870.2  907.59  4900.2  907.21
  4910.2  905.90  4950.3  904.76  4999.8  901.26  5000.3  898.26  5011.6  898.26
  5012.1  901.26  5021.7  902.53  5048.9  901.93  5058.3  902.82  5070.4  905.44
  5080.4  905.32  5086.1  906.22  5116.1  905.12  5174.0  907.45  5246.6  911.77
  5326.8  912.53  5394.0  910.75  5450.8  912.37  5540.1  918.26  5561.6  918.51
  5600.4  920.68  5647.2  922.72  5699.5  925.27  5722.0  926.83  5868.7  932.68
#Mann=7,-1,0
  4700.1    0.05       0  4999.8    0.03       0  5012.1    0.05       0
  5450.8    0.12       0  5600.4    0.05       0  5647.2    0.12       0
  5699.5    0.05       0
Bank Sta=4999.8,5012.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8742,486,486,486
BEGIN DESCRIPTION:
PENNINGTON CREEK 13.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872455.69     10229753.13      2872352.75     10229378.00
      2872155.70     10229303.12
#Sta/Elev= 30
  4611.0  916.68  4667.9  914.21  4707.5  910.16  4714.7  908.97  4756.2  906.38
  4787.3  905.01  4821.2  904.60  4839.2  905.50  4860.9  904.24  4895.3  904.94
  4911.7  903.46  4934.9  903.69  4942.9  903.13  4963.6  899.33  4969.4  898.85
  4984.3  899.31  4993.7  898.43  4994.2  895.43  5005.7  895.43  5006.2  898.43
  5018.3  899.25  5025.7  899.06  5039.7  904.63  5055.8  907.21  5093.1  909.81
  5135.5  911.94  5157.3  913.69  5165.6  914.93  5171.0  914.72  5210.8  916.50
#Mann=3,-1,0
  4611.0    0.05       0  4993.7    0.05       0  5006.2    0.05       0
Bank Sta=4993.7,5006.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8256,473,473,473
BEGIN DESCRIPTION:
PENNINGTON CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2872855.69     10229353.13      2872796.75     10229194.00
      2872605.68     10229053.11
#Sta/Elev= 30
  4830.3  909.94  4833.0  909.94  4851.7  907.47  4875.9  904.97  4894.3  903.77
  4906.3  901.83  4915.6  900.89  4926.0  900.19  4937.0  900.45  4947.6  899.79
  4956.4  898.07  4979.6  897.34  4985.9  895.42  4986.4  892.42  4997.9  892.42
  4998.4  895.42  5014.9  897.17  5044.2  897.11  5073.5  898.97  5079.7  900.10
  5100.7  901.48  5109.0  901.96  5115.2  901.74  5123.6  902.60  5159.1  904.41
  5165.3  904.27  5187.7  905.13  5200.8  906.14  5209.2  907.27  5237.4  908.30
#Mann=3,-1,0
  4830.3    0.05       0  4985.9    0.05       0  4998.4    0.05       0
Bank Sta=4985.9,4998.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7783,447,447,447
BEGIN DESCRIPTION:
PENNINGTON CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2873255.69     10229403.15      2873200.25     10228995.00
      2873155.69     10228603.13
#Sta/Elev= 30
  4588.1  910.67  4629.4  909.22  4709.2  907.66  4790.0  904.50  4820.3  904.48
  4846.8  905.43  4851.9  904.81  4890.9  903.24  4981.7  895.18  4991.8  895.16
  4993.7  894.38  4994.2  891.38  5005.8  891.38  5006.3  894.38  5012.0  895.43
  5022.0  895.19  5042.2  895.92  5062.3  894.90  5086.1  897.64  5122.7  899.21
  5152.9  899.39  5170.6  898.43  5175.6  899.50  5233.4  899.07  5253.5  899.57
  5313.9  904.20  5344.1  908.64  5349.6  910.19  5354.7  910.11  5394.4  915.63
#Mann=3,-1,0
  4588.1    0.05       0  4993.7    0.05       0  5006.3    0.05       0
Bank Sta=4993.7,5006.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7336,477,477,477
BEGIN DESCRIPTION:
PENNINGTON CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2873405.67     10229303.14      2873620.75     10228936.00
      2873205.68     10228553.11
#Sta/Elev= 30
  4574.5  908.54  4881.4  900.91  4924.4  898.40  4940.1  894.72  4961.5  895.76
  4977.2  893.29  4983.0  894.72  5005.9  891.18  5012.7  891.20  5034.1  896.20
  5055.2  896.95  5069.4  896.02  5076.2  893.58  5118.7  892.19  5119.8  891.04
  5120.3  888.04  5131.9  888.04  5132.4  891.04  5132.9  892.59  5140.3  892.46
  5147.1  894.18  5189.6  897.94  5281.4  898.00  5394.9  899.98  5444.2  905.86
  5458.4  906.25  5465.7  905.07  5479.9  906.12  5522.5  911.82  5564.7  919.12
#Mann=3,-1,0
  4574.5    0.05       0  5119.8    0.03       0  5132.4    0.05       0
Bank Sta=5119.8,5132.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6859,489,489,489
BEGIN DESCRIPTION:
PENNINGTON CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2873805.68     10229403.11      2874015.25     10228668.00
      2873805.68     10228303.10
#Sta/Elev= 30
  4235.6  907.26  4277.2  906.87  4510.2  899.55  4728.8  899.28  4947.4  894.78
  4963.5  893.64  4973.9  888.26  4974.9  886.81  4975.4  883.81  4987.1  883.81
  4987.6  886.81  4999.9  888.74  5010.3  888.97  5026.1  891.94  5063.3  889.33
  5069.2  890.00  5085.0  896.37  5090.8  895.67  5112.4  896.99  5144.0  895.18
  5178.6  898.47  5187.1  898.24  5236.3  901.89  5246.1  901.27  5259.3  903.38
  5310.8  906.16  5332.4  908.22  5363.1  913.98  5375.5  917.41  5420.8  921.30
#Mann=3,-1,0
  4235.6    0.05       0  4974.9    0.03       0  4987.6    0.05       0
Bank Sta=4974.9,4987.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6370,498,498,498
BEGIN DESCRIPTION:
PENNINGTON CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875105.69     10229203.12      2874491.00     10228579.00
      2874405.68     10228403.10
#Sta/Elev= 30
  4124.0  911.14  4223.0  905.13  4251.3  907.05  4279.5  901.53  4477.5  895.98
  4626.1  895.23  4633.1  892.74  4640.2  892.57  4647.3  888.96  4689.7  886.31
  4746.3  887.96  4753.4  886.37  4767.5  891.11  4810.0  890.24  4845.3  893.04
  4873.6  891.24  4951.4  892.74  4965.5  891.40  4972.2  885.72  4972.7  882.72
  4986.7  882.72  4987.2  885.72  5017.7  887.03  5023.4  891.57  5039.9  892.87
  5119.3  888.33  5128.8  890.72  5136.3  895.87  5151.0  898.95  5195.5  902.33
#Mann=3,-1,0
  4124.0    0.05       0  4972.2    0.05       0  4987.2    0.05       0
Bank Sta=4972.2,4987.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5872,477,477,477
BEGIN DESCRIPTION:
PENNINGTON CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875305.68     10228753.10      2874762.25     10228166.00
      2874505.69     10228003.11
#Sta/Elev= 30
  4200.0  905.69  4327.3  899.58  4447.5  895.52  4610.2  891.73  4745.0  892.65
  4758.8  890.48  4772.9  885.94  4787.1  886.46  4815.5  883.88  4837.0  883.61
  4843.8  886.14  4851.2  887.53  4900.5  888.25  4949.8  890.73  4957.2  890.26
  4971.4  887.43  4978.0  883.39  4978.5  880.39  4992.5  880.39  4993.0  883.39
  5007.8  884.12  5014.2  886.99  5056.6  890.22  5108.2  891.35  5144.7  895.25
  5165.8  895.89  5217.5  899.74  5238.7  899.78  5244.7  900.98  5303.9  904.68
#Mann=3,-1,0
  4200.0    0.05       0  4978.0    0.05       0  4993.0    0.05       0
Bank Sta=4978,4993
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5395,573,573,573
BEGIN DESCRIPTION:
PENNINGTON CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875405.67     10228153.10      2875088.75     10227841.00
      2874905.66     10227553.08
#Sta/Elev= 30
  4555.2  899.62  4633.0  895.68  4795.6  889.84  4831.0  884.87  4845.1  883.55
  4866.3  882.81  4873.4  881.87  4880.4  882.34  4901.7  881.02  4915.8  882.44
  4937.0  882.68  4944.1  884.27  4951.1  884.40  4958.3  885.54  4972.4  885.26
  4979.4  883.93  4986.6  883.52  4991.1  880.92  4991.6  877.92  5005.6  877.92
  5006.1  880.92  5015.2  881.90  5030.4  885.30  5044.9  889.66  5051.6  890.22
  5109.1  888.01  5197.2  887.70  5233.6  889.63  5254.8  891.42  5341.2  895.77
#Mann=3,-1,0
  4555.2    0.05       0  4991.1    0.05       0  5006.1    0.05       0
Bank Sta=4991.1,5006.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4822,573,573,573
BEGIN DESCRIPTION:
PENNINGTON CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875705.69     10228153.12      2875391.50     10227363.00
      2875105.67     10227003.09
#Sta/Elev= 30
  4149.7  908.56  4504.8  893.80  4720.1  887.41  4728.5  886.32  4787.9  885.28
  4795.4  883.76  4849.2  880.51  4866.1  881.09  4890.4  879.57  4925.5  879.93
  4956.8  878.91  4993.0  876.11  4993.5  873.11  5014.1  873.11  5014.6  876.11
  5018.2  881.25  5039.0  889.17  5210.5  888.55  5224.9  886.70  5231.3  887.41
  5245.7  886.67  5280.9  890.38  5289.0  892.89  5295.3  891.78  5303.4  894.38
  5317.8  895.75  5324.2  894.55  5338.6  898.60  5388.3  900.10  5459.6  904.40
#Mann=3,-1,0
  4149.7    0.05       0  4993.0    0.03       0  5014.6    0.05       0
Bank Sta=4993,5014.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4249,568,568,568
BEGIN DESCRIPTION:
PENNINGTON CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2875905.69     10227803.12      2875800.00     10226995.00
      2875605.67     10226403.08
#Sta/Elev= 30
  4185.0  899.74  4295.8  898.84  4379.7  896.65  4558.2  889.74  4719.5  887.05
  4769.9  884.45  4810.3  884.18  4838.0  881.60  4880.9  883.04  4941.4  881.87
  4951.5  881.19  4971.6  876.73  5001.6  874.57  5002.1  871.57  5023.0  871.57
  5023.5  874.57  5060.9  877.28  5092.7  876.58  5124.5  878.65  5129.8  876.74
  5149.3  878.81  5156.4  881.01  5161.6  879.76  5188.2  882.82  5244.1  886.21
  5257.1  888.23  5423.0  900.53  5448.0  901.48  5559.8  913.97  5623.0  918.46
#Mann=3,-1,0
  4185.0    0.05       0  5001.6    0.05       0  5023.5    0.05       0
Bank Sta=5001.6,5023.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3681,576,576,576
BEGIN DESCRIPTION:
PENNINGTON CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2876955.70     10227253.13      2876134.75     10226570.00
      2875705.66     10226403.10
#Sta/Elev= 30
  3932.0  897.68  4088.1  896.04  4244.2  884.91  4350.6  879.48  4358.4  881.50
  4372.7  881.58  4492.5  879.69  4514.6  882.14  4556.5  879.04  4592.7  883.28
  4706.0  882.76  4812.7  884.86  4841.4  883.26  4862.2  880.19  4868.7  877.53
  4883.0  876.35  4919.5  878.17  4964.5  871.93  4965.0  868.93  4985.9  868.93
  4986.4  871.93  5029.3  871.99  5052.6  874.24  5064.6  878.60  5095.6  883.04
  5168.0  884.91  5276.8  895.34  5336.6  904.07  5391.0  901.42  5460.4  914.26
#Mann=3,-1,0
  3932.0    0.05       0  4964.5    0.05       0  4986.4    0.05       0
Bank Sta=4964.5,4986.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3105,631,631,631
BEGIN DESCRIPTION:
PENNINGTON CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2877055.72     10226653.14      2876669.25     10226382.00
      2876405.67     10225803.08
#Sta/Elev= 30
  4527.9  895.64  4571.1  894.66  4636.5  888.57  4794.2  882.08  4815.1  880.13
  4850.9  873.34  4857.8  873.18  4882.7  877.52  4890.9  879.14  4907.5  880.36
  4966.8  874.07  4979.9  870.90  4982.8  868.69  4983.3  865.69  5004.3  865.69
  5004.8  868.69  5009.8  870.36  5041.0  872.95  5064.1  871.98  5086.7  872.88
  5092.6  875.61  5108.7  877.70  5144.2  881.62  5154.3  881.46  5218.9  883.01
  5416.3  883.08  5478.0  885.56  5547.1  891.91  5604.2  903.97  5636.1  907.88
#Mann=6,-1,0
  4527.9    0.05       0  4882.7    0.12       0  4890.9    0.05       0
  4982.8    0.05       0  5004.8    0.05       0  5154.3    0.12       0
Bank Sta=4982.8,5004.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2474,482,482,482
BEGIN DESCRIPTION:
Mapping XS 1ba65c27
END DESCRIPTION:
XS GIS Cut Line= 3
      2877199.72     10226102.11      2876765.68     10225702.79
      2876419.55     10225581.65
#Sta/Elev= 30
  4547.9  890.27  4567.4  889.89  4713.0  883.30  4748.1  882.84  4769.7  880.68
  4833.2  878.94  4861.5  876.42  4925.1  875.34  4953.4  872.56  4960.8  869.69
  4967.6  868.59  4988.6  868.29  4996.0  869.74  5031.1  868.18  5034.0  866.74
  5034.5  863.74  5056.1  863.74  5056.6  866.74  5059.5  872.43  5066.8  876.59
  5073.6  877.10  5081.0  879.57  5109.4  880.71  5178.4  880.70  5201.2  882.43
  5222.4  886.38  5233.0  887.07  5328.3  906.59  5349.6  909.24  5504.4  910.39
#Mann=4,-1,0
  4547.9    0.05       0  4567.4    0.12       0  5034.0    0.07       0
  5056.6    0.12       0
Bank Sta=5034,5056.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1992,1271,1271,1271
BEGIN DESCRIPTION:
Mapping XS dcd0484f
END DESCRIPTION:
XS GIS Cut Line= 3
      2877273.79     10225937.82      2877072.39     10225382.23
      2876719.48     10225160.79
#Sta/Elev= 30
  4313.2  890.55  4378.8  888.00  4562.9  881.51  4722.4  880.87  4730.4  879.54
  4735.7  880.65  4812.5  879.97  4871.3  877.85  4883.6  875.28  4914.3  873.62
  4951.5  871.87  4966.8  867.15  4982.1  867.25  4997.9  865.21  4998.4  862.21
  5020.0  862.21  5020.5  865.21  5039.8  870.87  5061.0  873.24  5097.6  881.66
  5103.5  881.05  5118.8  884.89  5124.7  883.62  5134.1  884.32  5170.6  889.45
  5176.5  888.39  5270.8  895.54  5286.1  898.48  5301.4  898.32  5320.8  900.85
#Mann=6,-1,0
  4313.2    0.05       0  4378.8    0.12       0  4812.5    0.05       0
  4914.3    0.12       0  4997.9    0.07       0  5020.5    0.12       0
Bank Sta=4997.9,5020.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,721,0,0,0
BEGIN DESCRIPTION:
PENNINGTON CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2878877.94     10224868.33      2877839.75     10224533.00
      2876926.55     10224840.56
#Sta/Elev= 30
  3909.0  897.43  4221.4  894.15  4484.1  891.66  4623.1  887.87  4692.4  883.11
  4799.4  878.72  4921.9  866.88  4960.3  860.49  4960.8  857.49  4984.7  857.49
  4985.2  860.49  5018.1  861.19  5035.9  865.14  5044.3  868.98  5067.6  872.51
  5081.1  870.84  5112.5  874.22  5298.0  878.06  5327.7  880.06  5333.0  882.98
  5352.5  881.63  5396.0  885.12  5415.8  884.23  5454.6  885.63  5611.3  890.12
  5767.9  894.91  5799.2  895.33  5924.6  895.49  5956.6  894.32  5963.6  894.36
#Mann=13,-1,0
  3909.0    0.05       0  4221.4    0.05       0  4484.1    0.05       0
  4799.4    0.05       0  4960.3    0.05       0  4985.2    0.05       0
  5298.0    0.05       0  5454.6    0.12       0  5611.3    0.12       0
  5767.9    0.05       0  5799.2    0.12       0  5924.6    0.12       0
  5956.6    0.05       0
Bank Sta=4960.3,4985.2
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
