HEC-RAS study WRIGHTS CREEK.prj: WRIGHTS CREEK Base Level Engineering

--- WRIGHTS CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,25097,574,574,574
BEGIN DESCRIPTION:
WRIGHTS CREEK 42.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2826855.67     10255153.10      2826095.75     10254583.00
      2825855.68     10253803.11
#Sta/Elev= 30
  4050.0 1087.72  4086.4 1083.76  4207.3 1075.49  4363.5 1071.10  4529.6 1068.72
  4678.1 1066.12  4707.3 1066.99  4721.8 1065.50  4776.3 1064.89  4892.7 1063.32
  4913.5 1060.65  4936.4 1060.00  4942.7 1056.31  4956.3 1056.10  4963.5 1053.84
  4978.1 1053.76  4978.6 1052.59  4979.1 1049.59  5006.2 1049.59  5006.7 1052.59
  5073.1 1055.47  5094.1 1058.56  5119.7 1058.23  5152.4 1062.64  5217.8 1061.49
  5293.6 1062.33  5470.7 1070.59  5648.4 1075.69  5767.9 1079.90  5816.0 1081.74
#Mann=7,-1,0
  4050.0    0.05       0  4529.6    0.12       0  4776.3    0.05       0
  4978.6    0.05       0  5006.7    0.05       0  5648.4    0.12       0
  5767.9    0.05       0
Bank Sta=4978.6,5006.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,24523,591,591,591
BEGIN DESCRIPTION:
WRIGHTS CREEK 41.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2827055.68     10254653.11      2826585.25     10254359.00
      2825905.65     10253703.08
#Sta/Elev= 30
  4445.2 1084.87  4480.6 1078.27  4539.5 1073.08  4610.9 1069.15  4720.5 1064.66
  4741.8 1065.53  4836.1 1062.45  4945.8 1063.18  4961.1 1060.96  4967.0 1057.66
  4991.0 1050.85  4996.9 1050.36  4997.4 1047.36  5024.6 1047.36  5025.1 1050.36
  5025.2 1052.04  5032.1 1053.18  5039.3 1052.80  5081.8 1058.52  5231.6 1064.24
  5336.2 1071.78  5393.8 1070.72  5446.2 1073.68  5491.8 1077.29  5585.5 1075.06
  5711.0 1073.81  5841.1 1078.53  5880.8 1079.68  5927.5 1083.51  5944.5 1085.34
#Mann=10,-1,0
  4445.2    0.05       0  4991.0    0.12       0  4996.9    0.07       0
  5025.1    0.12       0  5231.6    0.12       0  5393.8    0.05       0
  5446.2    0.12       0  5585.5    0.05       0  5841.1    0.12       0
  5927.5    0.05       0
Bank Sta=4996.9,5025.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,23932,571,571,571
BEGIN DESCRIPTION:
WRIGHTS CREEK 40.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2827405.66     10253753.12      2826941.25     10253925.00
      2826355.72     10253953.11
#Sta/Elev= 30
  4504.8 1076.08  4558.1 1075.05  4630.9 1070.63  4654.1 1070.54  4691.7 1066.54
  4846.0 1061.34  4863.4 1059.54  4868.8 1056.61  4888.5 1054.75  4893.8 1052.38
  4924.2 1053.62  4931.3 1052.46  4954.6 1052.18  4980.9 1050.24  4981.4 1047.24
  5008.6 1047.24  5009.1 1050.24  5015.6 1051.41  5035.6 1050.95  5062.8 1058.33
  5067.8 1057.74  5075.7 1059.05  5095.7 1059.74  5125.7 1057.92  5155.7 1057.85
  5272.2 1062.69  5346.0 1064.23  5406.0 1067.91  5542.5 1073.82  5586.2 1075.86
#Mann=4,-1,0
  4504.8    0.05       0  4980.9    0.05       0  5009.1    0.05       0
  5542.5    0.12       0
Bank Sta=4980.9,5009.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,23361,562,562,562
BEGIN DESCRIPTION:
WRIGHTS CREEK 39.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2827505.65     10253753.09      2826940.25     10253371.00
      2826155.70     10253053.12
#Sta/Elev= 30
  4317.6 1080.33  4340.0 1078.36  4439.0 1075.44  4583.1 1065.60  4691.1 1060.88
  4737.6 1059.25  4792.6 1057.83  4864.5 1059.96  4921.5 1055.87  4966.4 1055.91
  4972.4 1055.51  4979.3 1046.68  4979.8 1043.68  5007.1 1043.68  5007.6 1046.68
  5015.7 1049.24  5026.5 1049.97  5092.1 1048.44  5110.8 1053.58  5116.2 1053.37
  5140.3 1058.04  5164.4 1057.56  5199.3 1053.74  5223.4 1054.11  5242.1 1055.45
  5253.1 1058.08  5285.5 1060.03  5402.9 1062.37  5576.8 1068.46  5846.5 1082.64
#Mann=5,-1,0
  4317.6    0.05       0  4691.1    0.12       0  4737.6    0.05       0
  4979.3    0.03       0  5007.6    0.05       0
Bank Sta=4979.3,5007.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,22799,582,582,582
BEGIN DESCRIPTION:
WRIGHTS CREEK 38.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2827505.69     10253503.11      2827167.75     10252909.00
      2826355.65     10252953.11
#Sta/Elev= 30
  4316.5 1076.88  4346.1 1075.33  4351.8 1076.21  4374.0 1074.06  4397.0 1073.79
  4435.5 1070.74  4558.1 1063.84  4742.2 1055.92  4792.9 1055.17  4836.1 1056.04
  4874.5 1054.23  4889.5 1052.64  4903.2 1056.04  4916.8 1055.58  4960.8 1047.89
  4970.2 1046.72  4975.9 1047.12  4982.8 1045.40  4983.3 1042.40  5010.7 1042.40
  5011.2 1045.40  5032.1 1046.98  5062.2 1050.83  5082.2 1051.63  5112.2 1059.31
  5282.5 1058.32  5462.7 1063.25  5623.0 1066.16  5773.2 1071.22  5813.3 1073.41
#Mann=5,-1,0
  4316.5    0.05       0  4435.5    0.12       0  4874.5    0.05       0
  4982.8    0.03       0  5011.2    0.05       0
Bank Sta=4982.8,5011.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,22217,558,558,558
BEGIN DESCRIPTION:
WRIGHTS CREEK 37.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2828205.68     10253503.11      2827704.25     10252715.00
      2828005.68     10252303.12
#Sta/Elev= 30
  4065.9 1089.22  4167.5 1081.17  4209.8 1075.34  4344.8 1066.55  4548.6 1058.66
  4689.1 1055.78  4695.0 1053.83  4704.3 1055.23  4710.2 1052.31  4746.6 1055.22
  4761.9 1051.78  4767.8 1053.82  4783.0 1051.77  4848.2 1052.59  4892.3 1046.81
  4919.3 1045.61  4968.0 1046.74  4977.9 1044.81  4978.4 1041.81  5005.9 1041.81
  5006.4 1044.81  5015.9 1045.59  5039.0 1052.17  5066.1 1049.53  5095.4 1054.12
  5282.6 1061.67  5322.6 1063.09  5413.8 1067.95  5440.6 1069.56  5510.4 1071.97
#Mann=10,-1,0
  4065.9    0.05       0  4344.8    0.12       0  4548.6    0.05       0
  4968.0    0.12       0  4977.9    0.07       0  5006.4    0.12       0
  5282.6    0.05       0  5322.6    0.12       0  5413.8    0.05       0
  5440.6    0.12       0
Bank Sta=4977.9,5006.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,21659,591,591,591
BEGIN DESCRIPTION:
WRIGHTS CREEK 36.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2828505.69     10253203.12      2828216.25     10252890.00
      2828155.69     10252103.13
#Sta/Elev= 30
  4573.6 1088.73  4722.4 1080.66  4775.7 1074.33  4800.1 1071.76  4814.3 1068.43
  4821.1 1068.10  4828.5 1064.56  4849.5 1059.12  4913.5 1054.40  4941.3 1053.87
  4955.5 1050.91  4962.9 1048.12  4969.7 1051.13  4977.0 1046.79  4983.8 1047.89
  4991.2 1043.24  4992.7 1040.66  4993.2 1037.66  5020.7 1037.66  5021.2 1040.66
  5028.7 1042.49  5057.1 1044.25  5097.2 1044.25  5127.6 1046.51  5240.8 1052.63
  5338.0 1060.36  5538.5 1069.62  5621.9 1071.98  5720.7 1073.63  5789.2 1074.44
#Mann=9,-1,0
  4573.6    0.05       0  4775.7    0.12       0  4992.7    0.07       0
  5021.2    0.12       0  5028.7    0.05       0  5127.6    0.12       0
  5240.8    0.05       0  5621.9    0.12       0  5720.7    0.05       0
Bank Sta=4992.7,5021.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,21068,1141,1141,1141
BEGIN DESCRIPTION:
WRIGHTS CREEK 35.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2828605.70     10253153.08      2828787.00     10252776.00
      2828805.68     10252353.11
#Sta/Elev= 30
  4581.6 1089.90  4640.9 1086.49  4686.2 1081.79  4703.3 1078.23  4708.8 1079.54
  4731.5 1075.03  4737.0 1076.04  4776.7 1069.93  4804.9 1069.50  4822.0 1066.15
  4850.2 1063.99  4867.3 1059.57  4872.8 1060.46  4889.9 1055.65  4895.5 1056.95
  4905.3 1055.24  4935.2 1051.17  4940.7 1051.97  4957.8 1046.52  4963.4 1047.48
  4980.4 1042.69  4984.5 1038.73  4985.0 1035.73  5012.6 1035.73  5013.1 1038.73
  5032.9 1039.99  5080.7 1048.51  5282.8 1054.18  5380.9 1061.98  5423.3 1066.54
#Mann=6,-1,0
  4581.6    0.05       0  4905.3    0.12       0  4984.5    0.07       0
  5013.1    0.12       0  5282.8    0.05       0  5380.9    0.12       0
Bank Sta=4984.5,5013.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,19927,568,568,568
BEGIN DESCRIPTION:
WRIGHTS CREEK 33.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830305.67     10252453.11      2829866.50     10252423.00
      2829355.71     10252203.12
#Sta/Elev= 30
  4559.8 1066.86  4628.9 1062.98  4640.0 1059.63  4650.0 1058.73  4670.0 1058.09
  4690.1 1055.99  4740.2 1052.76  4794.1 1050.23  4850.5 1047.73  4925.5 1047.14
  4930.7 1044.52  4950.7 1043.88  4980.8 1037.26  4994.4 1036.81  4994.9 1033.81
  5023.7 1033.81  5024.2 1036.81  5038.3 1038.68  5061.9 1038.98  5090.8 1043.18
  5137.9 1045.51  5153.3 1047.48  5161.4 1047.47  5196.5 1050.79  5242.9 1054.45
  5261.0 1054.45  5381.9 1059.97  5447.5 1062.08  5489.1 1061.58  5556.1 1063.42
#Mann=5,-1,0
  4559.8    0.05       0  4794.1    0.12       0  4994.4    0.07       0
  5024.2    0.12       0  5196.5    0.05       0
Bank Sta=4994.4,5024.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,19359,465,465,465
BEGIN DESCRIPTION:
WRIGHTS CREEK 32.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830455.66     10251703.14      2830154.25     10251975.00
      2829505.70     10252203.11
#Sta/Elev= 30
  4594.1 1074.12  4622.1 1073.36  4707.3 1063.89  4714.7 1064.25  4721.5 1062.89
  4735.7 1063.65  4742.4 1061.82  4778.3 1060.23  4820.9 1055.60  4827.6 1053.54
  4835.1 1053.95  4856.0 1050.93  4870.2 1051.02  4898.6 1048.90  4919.5 1045.72
  4933.7 1045.44  4955.4 1040.69  4962.1 1041.52  4969.6 1038.95  4975.6 1035.37
  4976.1 1032.37  5004.9 1032.37  5005.4 1035.37  5006.6 1036.86  5019.7 1036.52
  5068.5 1042.16  5115.1 1044.74  5249.0 1048.25  5398.6 1049.75  5687.5 1060.58
#Mann=3,-1,0
  4594.1    0.05       0  4975.6    0.05       0  5005.4    0.05       0
Bank Sta=4975.6,5005.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,18894,400,400,400
BEGIN DESCRIPTION:
Mapping XS 037df6a8
END DESCRIPTION:
XS GIS Cut Line= 4
      2830346.17     10251309.43      2830064.03     10251483.05
      2829792.76     10251689.22      2829022.40     10252166.62
#Sta/Elev= 30
  4489.3 1062.15  4585.4 1065.19  4616.7 1065.72  4724.7 1065.68  4748.1 1068.00
  4754.0 1065.34  4762.0 1065.72  4790.7 1067.00  4806.1 1065.95  4812.0 1064.28
  4883.1 1058.09  4906.7 1053.89  4912.1 1053.86  4962.1 1038.96  4991.1 1036.51
  4997.4 1034.43  5012.0 1035.58  5017.9 1032.97  5018.4 1029.97  5047.2 1029.97
  5047.7 1032.97  5061.9 1038.13  5097.2 1042.68  5132.6 1044.92  5140.9 1042.24
  5198.1 1047.79  5402.5 1048.05  5807.7 1059.45  5967.2 1061.29  6067.6 1060.57
#Mann=8,-1,0
  4489.3    0.05       0  4585.4    0.12       0  4616.7    0.05       0
  4762.0    0.12       0  4906.7    0.05       0  5017.9    0.05       0
  5047.7    0.05       0  5967.2    0.12       0
Bank Sta=5017.9,5047.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,18494,771,771,771
BEGIN DESCRIPTION:
Mapping XS 5b018f6d
END DESCRIPTION:
XS GIS Cut Line= 4
      2830150.86     10251266.03      2829640.85     10251341.99
      2829326.18     10251504.75      2828642.60     10251341.99
#Sta/Elev= 30
  4426.4 1061.69  4583.3 1062.41  4704.6 1057.81  4785.5 1051.73  4809.3 1053.45
  4836.0 1052.47  4896.7 1043.00  4909.8 1043.89  4960.0 1037.16  4976.6 1037.40
  4989.4 1032.45  4989.9 1029.45  5018.7 1029.45  5019.2 1032.45  5020.8 1034.54
  5059.5 1035.07  5087.3 1043.55  5125.9 1046.41  5242.3 1044.43  5264.4 1043.22
  5280.9 1039.61  5299.1 1040.48  5307.1 1043.86  5323.7 1045.77  5353.0 1046.80
  5450.2 1050.98  5575.3 1061.22  5605.2 1063.26  5903.3 1053.07  5999.0 1054.99
#Mann=7,-1,0
  4426.4    0.05       0  4809.3    0.12       0  4909.8    0.05       0
  4989.4    0.03       0  5019.2    0.05       0  5353.0    0.12       0
  5575.3    0.05       0
Bank Sta=4989.4,5019.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,17723,595,595,595
BEGIN DESCRIPTION:
WRIGHTS CREEK 29.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2829805.69     10251203.11      2829176.50     10250830.00
      2828905.68     10250503.11
#Sta/Elev= 30
  4268.5 1059.32  4457.5 1053.69  4644.1 1045.11  4757.5 1039.33  4780.1 1038.68
  4814.9 1040.59  4866.9 1040.36  4919.5 1037.25  4931.2 1034.79  4968.2 1032.99
  4974.7 1029.48  4975.2 1026.48  5004.1 1026.48  5004.6 1029.48  5012.3 1033.08
  5019.5 1034.34  5055.3 1042.73  5061.8 1047.03  5069.6 1048.99  5076.1 1052.54
  5090.4 1056.44  5098.3 1057.24  5104.8 1059.65  5147.7 1063.88  5176.4 1070.29
  5211.6 1074.34  5246.7 1076.37  5304.0 1076.35  5351.4 1074.79  5424.5 1074.55
#Mann=7,-1,0
  4268.5    0.05       0  4644.1    0.12       0  4757.5    0.05       0
  4974.7    0.03       0  5004.6    0.05       0  5019.5    0.12       0
  5351.4    0.05       0
Bank Sta=4974.7,5004.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,17128,591,591,591
BEGIN DESCRIPTION:
WRIGHTS CREEK 28.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2829755.69     10251103.13      2829625.75     10250531.00
      2829455.68     10250153.11
#Sta/Elev= 30
  4413.3 1057.05  4571.8 1051.84  4658.0 1047.12  4706.2 1045.61  4782.5 1043.81
  4864.5 1043.59  4905.5 1040.41  4931.9 1035.91  4937.0 1035.91  4956.8 1031.73
  5004.6 1029.09  5005.1 1026.09  5034.1 1026.09  5034.6 1029.09  5036.4 1034.75
  5059.5 1037.62  5072.9 1038.10  5105.8 1038.38  5129.0 1040.63  5140.2 1043.64
  5180.8 1049.93  5186.3 1051.94  5203.9 1054.18  5209.4 1056.58  5249.9 1062.26
  5261.2 1065.88  5302.0 1071.11  5353.8 1072.32  5382.4 1074.98  5414.4 1076.07
#Mann=4,-1,0
  4413.3    0.05       0  5004.6    0.03       0  5034.6    0.05       0
  5072.9    0.12       0
Bank Sta=5004.6,5034.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,16537,482,482,482
BEGIN DESCRIPTION:
WRIGHTS CREEK 27.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830455.66     10250653.09      2830175.75     10250364.00
      2829755.65     10249803.07
#Sta/Elev= 30
  4597.6 1066.03  4767.2 1061.44  4818.1 1057.33  4818.9 1057.33  4901.7 1051.50
  4930.6 1042.73  4951.1 1038.62  4965.3 1032.60  4971.6 1026.32  4972.1 1023.32
  5001.2 1023.32  5001.7 1026.32  5003.7 1028.11  5022.5 1027.75  5037.1 1032.51
  5078.7 1035.86  5178.8 1037.76  5222.5 1040.31  5264.2 1040.46  5301.0 1042.30
  5314.2 1043.76  5387.1 1047.50  5487.2 1056.04  5493.4 1055.51  5537.2 1058.77
  5570.2 1062.08  5650.8 1069.34  5672.6 1072.85  5697.6 1079.04  5700.8 1079.04
#Mann=7,-1,0
  4597.6    0.05       0  4818.1    0.12       0  4818.9    0.05       0
  4930.6    0.12       0  4971.6    0.07       0  5001.7    0.12       0
  5570.2    0.05       0
Bank Sta=4971.6,5001.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,16055,588,588,588
BEGIN DESCRIPTION:
WRIGHTS CREEK 26.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830505.69     10250503.10      2830561.25     10250076.00
      2830605.68     10249653.13
#Sta/Elev= 30
  4569.3 1057.16  4624.3 1052.72  4685.4 1048.87  4690.5 1049.36  4710.5 1048.28
  4720.6 1046.62  4766.0 1043.68  4811.3 1041.01  4864.5 1036.27  4912.2 1033.88
  4917.6 1032.36  4922.7 1033.35  4947.1 1029.88  4962.6 1027.06  4997.9 1026.16
  4998.4 1023.16  5027.5 1023.16  5028.0 1026.16  5033.1 1030.69  5053.2 1033.65
  5133.6 1038.36  5182.4 1044.36  5187.5 1043.28  5214.1 1049.27  5244.2 1053.49
  5314.6 1059.29  5364.9 1061.78  5373.6 1061.18  5378.7 1061.95  5425.2 1062.15
#Mann=7,-1,0
  4569.3    0.05       0  4624.3    0.12       0  4766.0    0.05       0
  4864.5    0.12       0  4947.1    0.05       0  4997.9    0.05       0
  5028.0    0.05       0
Bank Sta=4997.9,5028
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,15467,452,452,452
BEGIN DESCRIPTION:
WRIGHTS CREEK 25.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831255.68     10250603.11      2831107.00     10249868.00
      2830705.66     10249703.10
#Sta/Elev= 30
  4250.0 1067.27  4362.2 1060.03  4392.8 1056.89  4566.3 1048.62  4625.4 1043.97
  4723.9 1039.65  4825.0 1033.91  4828.3 1033.58  4833.4 1035.28  4892.8 1032.09
  4913.2 1032.09  4934.8 1028.83  4943.8 1026.20  4950.8 1025.86  4994.8 1026.52
  4997.2 1025.33  4997.7 1022.33  5026.8 1022.33  5027.3 1025.33  5033.9 1030.34
  5077.7 1031.48  5092.3 1031.46  5128.5 1033.06  5205.8 1040.65  5224.5 1043.47
  5288.5 1049.08  5341.9 1052.19  5365.8 1055.81  5395.2 1056.21  5433.9 1058.85
#Mann=9,-1,0
  4250.0    0.05       0  4723.9    0.12       0  4825.0    0.05       0
  4950.8    0.12       0  4997.2    0.07       0  5027.3    0.12       0
  5077.7    0.05       0  5092.3    0.12       0  5224.5    0.05       0
Bank Sta=4997.2,5027.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,15015,579,579,579
BEGIN DESCRIPTION:
WRIGHTS CREEK 24.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831555.68     10250053.08      2831475.75     10249614.00
      2830655.71     10249553.11
#Sta/Elev= 30
  4553.7 1051.79  4675.6 1047.39  4745.4 1042.85  4767.1 1042.45  4817.9 1037.94
  4857.1 1038.49  4878.9 1037.63  4909.4 1034.57  4920.6 1031.94  4939.9 1030.66
  4960.2 1027.43  4965.5 1023.51  4966.0 1020.51  4995.2 1020.51  4995.7 1023.51
  4997.9 1024.83  5030.1 1023.65  5060.2 1028.89  5100.3 1030.57  5140.5 1031.39
  5240.7 1031.18  5310.9 1035.29  5401.2 1036.88  5491.4 1041.24  5543.2 1042.62
  5680.9 1051.16  5722.0 1053.60  5751.0 1056.53  5756.0 1055.97  5822.3 1059.34
#Mann=5,-1,0
  4553.7    0.05       0  4965.5    0.05       0  4995.7    0.05       0
  5543.2    0.12       0  5680.9    0.05       0
Bank Sta=4965.5,4995.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,14436,574,574,574
BEGIN DESCRIPTION:
WRIGHTS CREEK 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2832055.65     10248703.14      2831646.50     10249100.00
      2831105.69     10248953.11
#Sta/Elev= 30
  4430.0 1046.36  4493.6 1043.79  4627.9 1036.23  4649.2 1036.22  4734.1 1031.60
  4797.7 1029.56  4826.0 1027.32  4847.3 1027.69  4854.3 1028.57  4861.4 1027.85
  4917.8 1027.67  4925.0 1026.70  4946.1 1026.35  4953.3 1021.89  4959.3 1021.13
  4959.8 1018.13  4989.1 1018.13  4989.6 1021.13  5003.0 1022.22  5006.6 1024.32
  5021.6 1025.37  5041.2 1024.08  5046.4 1025.37  5052.7 1023.51  5094.1 1026.94
  5135.6 1025.58  5187.4 1027.13  5235.1 1030.51  5428.9 1040.63  5560.4 1050.78
#Mann=3,-1,0
  4430.0    0.05       0  4959.3    0.05       0  4989.6    0.05       0
Bank Sta=4959.3,4989.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,13862,490,490,490
BEGIN DESCRIPTION:
WRIGHTS CREEK 22.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831955.70     10248603.11      2831550.75     10248545.00
      2831155.68     10248653.11
#Sta/Elev= 30
  4590.9 1044.56  4625.5 1042.28  4655.5 1039.82  4681.8 1038.02  4696.8 1038.11
  4702.0 1036.34  4772.8 1030.39  4803.1 1029.51  4813.2 1027.96  4843.5 1026.30
  4908.4 1024.89  4914.2 1023.99  4944.5 1022.60  4954.6 1021.01  4979.0 1020.17
  4979.7 1018.65  4980.2 1015.65  5009.7 1015.65  5010.2 1018.65  5026.0 1019.46
  5045.6 1023.78  5050.8 1023.36  5057.1 1025.06  5090.5 1025.93  5181.5 1034.98
  5191.9 1036.72  5218.4 1039.33  5263.1 1043.67  5318.2 1047.79  5409.6 1052.93
#Mann=7,-1,0
  4590.9    0.05       0  4625.5    0.12       0  4655.5    0.05       0
  4979.7    0.03       0  5010.2    0.05       0  5218.4    0.12       0
  5263.1    0.05       0
Bank Sta=4979.7,5010.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,13372,553,553,553
BEGIN DESCRIPTION:
WRIGHTS CREEK 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831705.66     10247903.12      2831388.25     10248095.00
      2831155.67     10248303.12
#Sta/Elev= 30
  4629.1 1037.49  4716.4 1033.15  4737.7 1031.78  4759.1 1029.37  4804.4 1026.39
  4839.4 1025.53  4848.3 1025.91  4869.7 1024.09  4912.4 1024.21  4921.2 1023.55
  4933.7 1019.24  4943.4 1017.93  4956.3 1018.87  4983.3 1017.53  4983.8 1014.53
  5013.3 1014.53  5013.8 1017.53  5014.9 1018.59  5021.6 1018.31  5043.3 1021.43
  5057.1 1021.74  5070.9 1023.51  5121.1 1024.29  5142.0 1026.58  5170.4 1027.35
  5184.6 1029.08  5227.2 1030.22  5269.9 1034.04  5290.8 1034.93  5312.1 1037.10
#Mann=3,-1,0
  4629.1    0.05       0  4983.3    0.05       0  5013.8    0.05       0
Bank Sta=4983.3,5013.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12819,592,592,592
BEGIN DESCRIPTION:
WRIGHTS CREEK 20.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831655.71     10247253.09      2830909.00     10247842.00
      2831055.69     10248453.14
#Sta/Elev= 30
  4049.0 1062.67  4190.9 1053.13  4240.6 1047.75  4277.6 1046.76  4283.9 1044.94
  4418.6 1039.40  4482.7 1039.63  4583.8 1034.61  4625.4 1031.51  4689.5 1023.94
  4753.7 1021.23  4811.5 1015.18  4832.3 1017.05  4875.6 1016.81  4946.1 1021.70
  4975.0 1019.41  4980.5 1014.26  4981.0 1011.26  5010.5 1011.26  5011.0 1014.26
  5011.9 1015.94  5021.7 1017.33  5135.5 1021.29  5305.8 1031.08  5353.0 1029.95
  5474.0 1038.35  5520.9 1042.80  5568.1 1044.29  5604.9 1048.62  5628.5 1048.58
#Mann=5,-1,0
  4049.0    0.05       0  4980.5    0.03       0  5011.0    0.05       0
  5135.5    0.12       0  5474.0    0.05       0
Bank Sta=4980.5,5011
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,12227,582,582,582
BEGIN DESCRIPTION:
WRIGHTS CREEK 19.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830305.68     10247253.12      2830333.75     10247733.00
      2829855.68     10248103.12
#Sta/Elev= 30
  4519.3 1041.97  4549.3 1040.09  4639.5 1030.93  4775.5 1022.88  4780.5 1023.40
  4789.8 1021.51  4799.8 1020.95  4809.8 1021.25  4839.8 1018.89  4930.0 1015.89
  4951.3 1013.60  4970.1 1012.90  4974.7 1010.26  4975.2 1007.26  5004.9 1007.26
  5005.4 1010.26  5006.1 1011.57  5035.1 1011.67  5048.1 1010.77  5120.2 1011.69
  5134.7 1012.23  5141.0 1014.11  5170.0 1015.20  5176.3 1016.51  5333.9 1021.38
  5433.5 1027.86  5462.4 1028.77  5554.0 1039.33  5591.0 1043.03  5604.6 1043.37
#Mann=3,-1,0
  4519.3    0.05       0  4974.7    0.05       0  5005.4    0.05       0
Bank Sta=4974.7,5005.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11645,559,559,559
BEGIN DESCRIPTION:
WRIGHTS CREEK 18.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830205.70     10247153.09      2829763.00     10247643.00
      2829555.70     10248003.09
#Sta/Elev= 30
  4339.7 1044.39  4361.0 1043.47  4367.8 1042.03  4389.4 1040.80  4424.5 1036.92
  4509.7 1032.28  4544.9 1029.40  4644.2 1025.21  4792.9 1021.12  4828.1 1018.77
  4835.5 1017.38  4842.3 1018.18  4870.7 1015.54  4934.2 1015.20  4948.4 1013.66
  4962.6 1008.96  4968.9 1005.76  4969.4 1002.76  4999.1 1002.76  4999.6 1005.76
  5005.3 1005.91  5021.1 1009.23  5101.5 1017.70  5144.7 1024.96  5182.0 1029.67
  5225.1 1033.59  5289.8 1041.79  5299.8 1041.90  5348.7 1046.62  5415.5 1048.84
#Mann=3,-1,0
  4339.7    0.05       0  4968.9    0.05       0  4999.6    0.05       0
Bank Sta=4968.9,4999.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,11086,682,682,682
BEGIN DESCRIPTION:
WRIGHTS CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830055.64     10247003.13      2829544.25     10247162.00
      2829305.66     10247503.15
#Sta/Elev= 30
  4464.5 1039.89  4506.3 1036.46  4558.7 1029.84  4583.6 1028.90  4611.0 1026.08
  4726.2 1021.78  4799.5 1022.98  4893.8 1017.94  4946.1 1013.16  4952.3 1011.57
  4977.6 1010.17  4998.2 1005.77  4998.7 1002.77  5028.4 1002.77  5028.9 1005.77
  5093.2 1006.51  5099.3 1009.60  5108.0 1010.45  5135.6 1009.59  5158.6 1010.80
  5244.9 1020.74  5271.9 1026.60  5294.2 1029.89  5301.6 1032.34  5322.5 1034.47
  5337.3 1037.36  5373.1 1037.73  5387.9 1039.13  5394.0 1038.29  5416.3 1040.79
#Mann=3,-1,0
  4464.5    0.05       0  4998.2    0.03       0  5028.9    0.05       0
Bank Sta=4998.2,5028.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10404,235,235,235
BEGIN DESCRIPTION:
WRIGHTS CREEK 16.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830029.17     10246684.89      2829640.48     10246541.78
      2829229.96     10246235.48
#Sta/Elev= 30
  4609.9 1023.09  4685.1 1020.88  4720.9 1018.64  4801.6 1016.56  4837.4 1014.73
  4857.2 1014.80  4862.6 1013.94  4887.7 1013.74  4923.5 1008.89  4943.3 1007.49
  4954.6 1005.42  4979.0 1004.03  4987.5 1002.58  4988.1  999.58  5020.2  999.58
  5020.8 1002.58  5024.0 1005.43  5047.9 1005.94  5097.9 1004.98  5112.5 1007.13
  5118.8 1009.05  5133.4 1010.07  5241.8 1011.14  5333.5 1014.40  5398.1 1018.45
  5419.0 1020.72  5483.6 1023.43  5498.2 1024.76  5533.6 1026.25  5536.3 1026.92
#Mann=3,-1,0
  4609.9    0.05       0  4987.5    0.05       0  5020.8    0.05       0
Bank Sta=4987.5,5020.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10169,592,592,592
BEGIN DESCRIPTION:
WRIGHTS CREEK 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2829855.67     10246553.07      2829803.50     10246363.00
      2829505.68     10246053.11
#Sta/Elev= 30
  4802.9 1014.96  4813.2 1014.73  4820.1 1013.52  4825.3 1013.26  4859.7 1012.19
  4875.4 1010.05  4894.2 1008.39  4906.6 1005.98  4916.9 1005.04  4927.3 1004.92
  4958.4 1003.14  4968.2 1004.80  4979.1 1003.24  5010.1 1002.54  5010.7  999.54
  5042.8  999.54  5043.4 1002.54  5047.9 1007.37  5076.2 1009.37  5097.3 1007.80
  5104.5 1008.50  5117.7 1008.50  5132.8 1009.28  5224.6 1010.61  5231.8 1011.25
  5252.9 1011.29  5260.1 1011.91  5267.1 1011.48  5359.2 1013.56  5429.8 1016.38
#Mann=3,-1,0
  4802.9    0.05       0  5010.1    0.05       0  5043.4    0.05       0
Bank Sta=5010.1,5043.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9577,1041,1041,1041
BEGIN DESCRIPTION:
WRIGHTS CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2830205.68     10246953.11      2830315.00     10246137.00
      2829505.69     10245353.12
#Sta/Elev= 30
  4176.6 1044.63  4286.1 1036.51  4364.1 1032.35  4378.4 1032.63  4408.7 1029.19
  4481.0 1027.45  4509.5 1027.98  4515.1 1026.16  4539.8 1025.64  4563.8 1023.18
  4666.1 1016.80  4751.7 1013.26  4817.1 1012.14  4903.0 1006.77  4923.2 1002.65
  4973.7 1003.19  4992.7 1001.42  4993.3  998.42  5025.5  998.42  5026.1 1001.42
  5030.5 1003.19  5066.0 1006.65  5072.9 1009.15  5094.3 1010.34  5157.8 1011.24
  5278.0 1007.76  5362.9 1007.95  5709.4 1016.89  5914.6 1026.01  6126.7 1033.55
#Mann=5,-1,0
  4176.6    0.05       0  4481.0    0.12       0  4563.8    0.05       0
  4992.7    0.03       0  5026.1    0.05       0
Bank Sta=4992.7,5026.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8536,581,581,581
BEGIN DESCRIPTION:
WRIGHTS CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831355.71     10245803.14      2830960.25     10245376.00
      2831105.68     10244703.14
#Sta/Elev= 30
  4417.9 1029.64  4729.5 1009.12  4913.2 1000.30  4920.6  999.49  4924.7  995.53
  4925.4  992.53  4957.7  992.53  4958.3  995.53  4963.1  997.85  5013.2  998.77
  5074.6 1002.66  5125.7 1003.00  5156.4 1000.50  5176.9 1005.02  5186.7 1005.21
  5191.8 1004.69  5207.6  998.02  5235.9  996.35  5258.8  997.67  5334.4 1006.34
  5350.8 1010.43  5371.3 1012.59  5402.0 1009.87  5412.2 1011.82  5427.8 1009.88
  5459.4 1011.98  5535.0 1016.87  5575.9 1015.13  5596.3 1021.41  5688.4 1026.19
#Mann=5,-1,0
  4417.9    0.05       0  4924.7    0.05       0  4958.3    0.05       0
  5258.8    0.12       0  5459.4    0.05       0
Bank Sta=4924.7,4958.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7955,589,589,589
BEGIN DESCRIPTION:
WRIGHTS CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2831455.69     10245603.09      2831478.25     10245186.00
      2831455.68     10244503.07
#Sta/Elev= 30
  4582.3 1019.99  4749.9 1009.12  4848.1 1004.24  4922.8 1002.34  4946.2 1000.52
  4981.8  993.66  4982.5  990.66  5015.3  990.66  5016.0  993.66  5044.5  996.02
  5193.0 1005.75  5323.1 1010.23  5339.9 1013.77  5353.1 1016.49  5363.1 1016.90
  5403.1 1014.67  5423.1 1017.24  5450.3 1018.02  5473.1 1020.47  5503.2 1025.39
  5530.0 1026.72  5535.0 1025.69  5543.2 1026.06  5563.2 1028.41  5573.2 1031.10
  5593.2 1032.97  5603.2 1032.92  5623.2 1035.21  5643.2 1035.71  5683.3 1039.08
#Mann=9,-1,0
  4582.3    0.05       0  4749.9    0.12       0  4848.1    0.05       0
  4946.2    0.12       0  4981.8    0.07       0  5016.0    0.12       0
  5044.5    0.05       0  5339.9   0.075       0  5450.3    0.05       0
Bank Sta=4981.8,5016
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7366,592,592,592
BEGIN DESCRIPTION:
WRIGHTS CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2832055.69     10245853.14      2832019.25     10245082.00
      2831505.69     10244553.12
#Sta/Elev= 30
  4228.0 1033.78  4248.1 1030.85  4522.8 1016.57  4544.6 1013.41  4578.4 1012.98
  4728.6 1003.03  4748.6 1006.71  4838.7  997.36  4848.7  997.91  4858.7 1001.57
  4921.8  996.33  4991.8  991.71  4992.4  988.71  5025.3  988.71  5026.0  991.71
  5037.2  997.88  5228.0 1001.49  5355.3 1006.58  5376.5 1008.38  5410.7 1014.54
  5447.2 1014.12  5468.5 1011.45  5562.0 1015.01  5638.3 1020.65  5701.8 1030.44
  5716.0 1037.29  5723.2 1044.90  5730.1 1043.27  5733.7 1045.96  5737.2 1045.96
#Mann=7,-1,0
  4228.0    0.12       0  4522.8    0.05       0  4921.8    0.12       0
  4991.8    0.07       0  5026.0    0.12       0  5410.7   0.075       0
  5562.0    0.05       0
Bank Sta=4991.8,5026
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6774,699,699,699
BEGIN DESCRIPTION:
WRIGHTS CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2832355.67     10245553.16      2832574.75     10244980.00
      2832755.70     10244303.07
#Sta/Elev= 30
  4386.4 1019.32  4595.9 1008.20  4611.3 1008.55  4620.6 1006.87  4650.6 1004.82
  4760.2 1000.25  4771.9  997.86  4795.6  997.99  4875.1  993.74  4905.1  993.61
  4911.0  992.42  4975.3  992.13  4989.9  990.71  4990.6  987.71  5023.6  987.71
  5024.3  990.71  5038.2  991.19  5057.7  996.26  5079.6  998.35  5102.9  997.27
  5172.7  997.15  5390.1 1009.36  5413.1 1009.75  5431.5 1008.21  5441.9 1010.67
  5472.9 1012.35  5535.0 1013.09  5568.2 1014.92  5628.2 1014.86  5700.7 1017.55
#Mann=3,-1,0
  4386.4    0.05       0  4989.9    0.05       0  5024.3    0.05       0
Bank Sta=4989.9,5024.3
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6075,356,356,356
BEGIN DESCRIPTION:
Mapping XS 8e25289f
END DESCRIPTION:
XS GIS Cut Line= 2
      2833210.73     10245829.88      2833156.49     10244267.73
#Sta/Elev= 30
  4408.2 1016.32  4605.1 1009.87  4855.2  997.93  4905.3  998.55  4925.3  995.98
  4955.3  994.82  4983.2  990.20  4988.1  986.89  4988.8  983.89  5021.9  983.89
  5022.6  986.89  5065.4  988.38  5095.4  991.42  5125.4  991.26  5135.4  993.02
  5165.4  992.33  5195.4  994.38  5215.5  998.73  5225.5  999.19  5345.5  997.22
  5425.6  998.70  5465.6 1001.28  5555.7 1003.61  5561.5 1005.31  5566.5 1004.05
  5685.7 1007.00  5735.8 1013.28  5755.8 1013.50  5775.8 1011.14  5971.3 1018.48
#Mann=3,-1,0
  4408.2    0.05       0  4988.1    0.05       0  5022.6    0.05       0
Bank Sta=4988.1,5022.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5719,538,538,538
BEGIN DESCRIPTION:
WRIGHTS CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2833755.67     10245953.08      2833540.75     10245204.00
      2833655.69     10244603.09
#Sta/Elev= 30
  4220.7 1032.74  4231.1 1034.04  4242.7 1030.15  4271.3 1024.65  4303.9 1021.11
  4315.4 1021.61  4343.9 1018.68  4489.3 1011.12  4558.7 1009.40  4765.7  999.36
  4891.6  994.49  4925.3  989.87  4959.0  989.52  4969.7  988.28  4973.3  985.49
  4974.0  982.49  5007.1  982.49  5007.8  985.49  5062.0  988.36  5153.6  996.59
  5174.0  994.73  5245.3  994.57  5286.0  992.18  5357.2  995.40  5398.0  994.79
  5438.7  997.15  5469.2 1002.10  5499.8 1003.38  5528.6 1006.78  5611.8 1010.36
#Mann=5,-1,0
  4220.7    0.05       0  4558.7    0.12       0  4765.7    0.05       0
  4973.3    0.03       0  5007.8    0.05       0
Bank Sta=4973.3,5007.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5181,593,593,593
BEGIN DESCRIPTION:
WRIGHTS CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2833805.67     10245903.15      2834067.00     10245122.00
      2834055.69     10244703.15
#Sta/Elev= 30
  4176.3 1035.66  4192.1 1034.77  4218.4 1028.04  4223.7 1029.15  4229.1 1024.29
  4250.0 1016.42  4255.3 1017.03  4271.2 1011.47  4292.3 1009.45  4324.0 1009.55
  4350.0 1007.04  4571.1  999.98  4692.1 1000.43  4723.7  997.59  4786.8  996.29
  4792.1  997.43  4818.4  994.04  4886.8  992.51  4935.6  988.00  4966.5  987.45
  4981.6  986.78  5001.6  983.03  5002.3  980.03  5035.5  980.03  5036.2  983.03
  5048.9  987.33  5088.9  994.11  5243.4 1006.52  5361.3 1010.90  5419.0 1012.57
#Mann=6,-1,0
  4176.3    0.05       0  4966.5    0.12       0  5001.6    0.07       0
  5036.2    0.12       0  5243.4    0.05       0  5361.3    0.12       0
Bank Sta=5001.6,5036.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4588,522,522,522
BEGIN DESCRIPTION:
WRIGHTS CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2833805.68     10245953.11      2834570.00     10245331.00
      2835005.72     10245053.09
#Sta/Elev= 30
  4014.5 1045.78  4036.1 1045.06  4042.5 1042.69  4064.8 1040.62  4071.2 1037.49
  4085.6 1037.79  4106.4 1029.63  4128.7 1018.03  4143.1 1013.91  4184.7 1007.98
  4270.9 1001.05  4433.9  995.69  4526.6  998.48  4704.0  999.09  4855.4  992.87
  4885.5  990.27  4945.3  985.75  4971.1  981.92  4971.8  978.92  5005.0  978.92
  5005.7  981.92  5030.5  986.08  5054.2  984.71  5060.6  987.00  5103.0  991.06
  5112.3  989.10  5245.5  997.10  5415.2 1009.49  5451.6 1015.75  5516.8 1020.26
#Mann=6,-1,0
  4014.5    0.05       0  4855.4    0.12       0  4885.5    0.05       0
  4971.1    0.05       0  5005.7    0.05       0  5245.5    0.05       0
Bank Sta=4971.1,5005.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4066,475,475,475
BEGIN DESCRIPTION:
WRIGHTS CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2834705.68     10246503.16      2834770.00     10245802.00
      2835055.66     10245403.14
#Sta/Elev= 30
  4295.9 1011.97  4466.7 1001.76  4587.2  998.56  4727.8  987.55  4757.9  986.34
  4790.8  986.75  4812.1  984.33  4838.2  982.19  4858.3  979.94  4868.3  980.95
  4908.5  980.79  4918.5  980.12  4921.3  978.76  4922.0  975.76  4955.2  975.76
  4956.0  978.76  5010.9  978.91  5047.2  982.70  5053.3  985.09  5082.8  985.85
  5088.5  985.22  5154.1  990.59  5160.2  992.13  5195.8  995.58  5296.6 1001.87
  5326.6 1001.45  5382.5 1005.15  5404.5 1007.76  5447.6 1009.72  5490.6 1014.32
#Mann=7,-1,0
  4295.9    0.05       0  4812.1    0.12       0  4838.2    0.05       0
  4921.3    0.05       0  4956.0    0.05       0  5088.5    0.12       0
  5326.6    0.05       0
Bank Sta=4921.3,4956
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3591,567,567,567
BEGIN DESCRIPTION:
WRIGHTS CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2835605.71     10246203.12      2835176.50     10245962.00
      2835105.68     10245553.09
#Sta/Elev= 30
  4507.7 1003.68  4606.0  994.26  4677.7  988.66  4710.0  984.89  4748.6  982.57
  4780.3  982.62  4802.0  984.08  4829.4  983.78  4851.8  980.70  4861.3  981.47
  4888.7  978.55  4910.4  979.28  4942.3  978.46  4948.0  980.40  4963.9  979.45
  4969.7  977.65  4985.6  978.48  4991.4  978.20  4991.5  977.24  4992.2  974.24
  5025.8  974.24  5026.6  977.24  5034.2  979.64  5039.5  978.53  5049.6  978.53
  5059.8  981.82  5088.9  983.11  5208.4  994.76  5283.0  997.75  5415.0 1007.53
#Mann=5,-1,0
  4507.7    0.05       0  4606.0    0.12       0  4710.0    0.05       0
  4991.5    0.05       0  5026.6    0.05       0
Bank Sta=4991.5,5026.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3024,1500,1500,1500
BEGIN DESCRIPTION:
WRIGHTS CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2835705.69     10246153.15      2835648.75     10245698.00
      2835305.67     10245403.10
#Sta/Elev= 30
  4541.3 1003.98  4650.8  994.91  4803.4  983.00  4884.0  980.53  4894.1  979.62
  4901.5  976.16  4974.7  974.70  4984.5  971.67  5009.6  969.05  5010.4  966.05
  5044.0  966.05  5044.7  969.05  5083.2  980.86  5090.8  981.48  5105.1  985.87
  5111.7  989.58  5119.3  990.78  5133.6  997.64  5147.9 1002.06  5183.0 1007.26
  5189.6 1012.19  5197.3 1010.27  5203.8 1013.94  5218.1 1013.01  5225.8 1009.52
  5275.2 1006.18  5296.0 1007.37  5311.7 1006.18  5395.9 1006.16  5452.4 1011.23
#Mann=6,-1,0
  4541.3    0.12       0  4650.8    0.05       0  4984.5    0.12       0
  5009.6    0.07       0  5044.7    0.12       0  5311.7    0.05       0
Bank Sta=5009.6,5044.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1524,0,0,0
BEGIN DESCRIPTION:
WRIGHTS CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 4
      2837453.37     10245743.05      2836794.50     10244826.00
      2836736.24     10244685.04      2834816.69     10244473.51
#Sta/Elev= 30
  3870.8 1014.25  4119.2  999.14  4127.8  995.89  4442.1  984.32  4507.2  977.00
  4634.9  978.01  4765.0  970.52  4785.9  973.45  4969.6  956.99  4970.3  953.99
  5004.1  953.99  5004.9  956.99  5038.6  961.27  5068.0  973.31  5091.8  973.61
  5133.4  981.35  5163.1  984.55  5203.4  981.52  5259.9  986.42  5324.1  991.60
  5409.6  991.59  5580.8  989.34  5998.2 1005.38  6159.1 1004.95  6501.2 1020.74
  6652.1 1020.08  6742.6 1015.45  6833.2 1017.29  6949.6 1025.71  7083.7 1026.09
#Mann=6,-1,0
  3870.8    0.05       0  4969.6    0.05       0  5004.9    0.05       0
  5133.4    0.12       0  5259.9    0.05       0  5409.6    0.05       0
Bank Sta=4969.6,5004.9
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
