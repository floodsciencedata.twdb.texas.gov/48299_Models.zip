HEC-RAS study WATERS CREEK.prj: WATERS CREEK Base Level Engineering

--- WATERS CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,10895,483,483,483
BEGIN DESCRIPTION:
WATERS CREEK 18.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854155.72     10228653.09      2854323.75     10228539.00
      2854405.67     10228353.15
#Sta/Elev= 30
  4796.9  974.31  4804.3  975.39  4819.3  975.91  4825.3  974.51  4833.1  976.33
  4840.3  975.53  4846.3  973.12  4855.2  971.43  4861.2  968.08  4876.2  963.07
  4882.2  959.97  4897.2  955.06  4946.8  947.20  4954.1  945.16  4959.8  941.09
  4960.3  940.59  4978.2  941.09  4984.0  942.60  5006.4  942.05  5014.5  943.08
  5020.0  945.43  5028.3  947.68  5037.9  949.16  5061.1  948.90  5072.1  947.04
  5082.9  947.68  5136.6  953.05  5142.1  954.68  5157.2  956.73  5203.1  963.07
#Mann=5,-1,0
  4796.9    0.05       0  4946.8    0.12       0  4959.8    0.07       0
  4978.2    0.12       0  5157.2    0.05       0
Bank Sta=4959.8,4978.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,10412,478,478,478
BEGIN DESCRIPTION:
WATERS CREEK 17.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854305.66     10229453.15      2854698.50     10228833.00
      2854855.68     10228703.12
#Sta/Elev= 30
  4265.9  964.95  4331.2  960.91  4649.8  948.63  4686.3  949.89  4692.2  948.80
  4707.5  949.11  4722.7  951.07  4795.6  951.71  4832.1  950.55  4875.0  947.25
  4885.0  946.69  4947.3  941.32  4968.5  941.96  4987.6  940.47  4988.1  939.97
  5006.4  940.47  5011.7  942.75  5019.6  944.13  5048.2  946.89  5054.7  949.68
  5061.2  954.31  5075.6  958.45  5112.1  959.20  5126.1  962.64  5132.9  961.97
  5147.2  963.04  5153.7  965.46  5190.3  969.69  5196.7  971.72  5203.9  971.40
#Mann=5,-1,0
  4265.9    0.05       0  4875.0    0.12       0  4885.0    0.05       0
  4987.6    0.05       0  5006.4    0.05       0
Bank Sta=4987.6,5006.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9934,478,478,478
BEGIN DESCRIPTION:
WATERS CREEK 16.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2854905.69     10229453.09      2854973.75     10229217.00
      2855305.68     10228753.12
#Sta/Elev= 30
  4754.3  968.75  4766.1  968.51  4775.6  967.25  4867.2  960.75  4877.3  960.57
  4889.6  957.89  4900.0  957.50  4921.4  948.28  4949.8  941.22  4955.0  938.61
  4968.2  937.27  4979.2  935.75  4979.7  935.25  4998.1  935.75  4999.4  937.44
  5044.3  939.57  5054.0  940.73  5082.7  940.42  5112.2  942.62  5162.5  948.69
  5204.3  952.12  5239.9  953.63  5267.9  953.21  5434.6  966.50  5445.0  966.32
  5470.9  968.09  5491.8  971.18  5533.6  973.20  5549.2  975.37  5570.4  978.49
#Mann=12,-1,0
  4754.3    0.05       0  4766.1    0.12       0  4775.6    0.05       0
  4867.2    0.12       0  4968.2    0.05       0  4979.2    0.05       0
  4998.1    0.05       0  5044.3    0.12       0  5267.9    0.05       0
  5434.6    0.12       0  5445.0    0.05       0  5549.2    0.12       0
Bank Sta=4979.2,4998.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,9456,473,473,473
BEGIN DESCRIPTION:
WATERS CREEK 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2855205.72     10229603.09      2855333.00     10229526.00
      2855405.68     10229253.11
#Sta/Elev= 30
  4851.2  957.88  4854.1  957.88  4864.7  955.06  4895.7  952.16  4901.6  952.54
  4909.6  951.39  4922.9  948.06  4932.6  946.84  4938.4  945.07  4953.9  943.54
  4968.1  941.26  4975.3  939.18  4981.1  936.49  4998.6  932.25  5003.9  932.23
  5004.4  931.73  5022.3  931.73  5022.8  932.23  5034.5  936.81  5054.7  938.01
  5064.3  938.09  5085.8  940.81  5109.6  942.35  5127.2  942.64  5168.6  944.33
  5184.7  945.59  5224.8  947.18  5238.9  948.43  5251.4  949.87  5282.4  952.05
#Mann=4,-1,0
  4851.2    0.05       0  5003.9    0.05       0  5022.8    0.05       0
  5238.9    0.05       0
Bank Sta=5003.9,5022.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8983,606,606,606
BEGIN DESCRIPTION:
WATERS CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2855655.70     10229953.08      2855755.00     10229723.00
      2855455.67     10229103.08
#Sta/Elev= 30
  4749.4  973.75  4758.4  972.73  4792.9  964.59  4803.8  963.41  4825.6  957.81
  4857.9  952.63  4863.3  953.91  4880.1  953.39  4915.8  955.91  4933.9  949.41
  4939.3  949.54  4945.4  944.68  4962.8  938.04  4968.3  937.74  4976.9  930.22
  4977.4  929.72  4995.8  930.22  5007.7  931.63  5022.4  931.06  5035.8  931.14
  5052.9  934.30  5058.4  933.55  5066.5  935.13  5075.5  934.95  5120.7  940.10
  5171.5  941.29  5255.3  940.21  5397.5  944.37  5491.8  949.01  5688.4  958.26
#Mann=5,-1,0
  4749.4    0.05       0  4976.9    0.05       0  4995.8    0.05       0
  5022.4    0.12       0  5491.8    0.05       0
Bank Sta=4976.9,4995.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8377,312,312,312
BEGIN DESCRIPTION:
Mapping XS 81b25e38
END DESCRIPTION:
XS GIS Cut Line= 4
      2856219.91     10229676.03      2856011.60     10229321.90
      2855589.72     10229092.73      2855464.77     10228848.04
#Sta/Elev= 30
  4300.0  954.85  4356.6  954.03  4378.1  955.37  4545.8  952.68  4629.1  948.31
  4804.5  939.31  4847.8  936.81  4906.3  936.03  4944.4  930.03  5006.2  927.81
  5006.7  927.31  5025.1  927.81  5031.8  931.87  5085.0  937.73  5119.2  939.88
  5135.4  943.10  5141.1  942.04  5157.2  945.80  5162.9  944.41  5190.4  949.56
  5259.2  955.34  5275.8  954.85  5314.0  957.82  5320.2  956.23  5325.8  957.58
  5342.4  956.86  5386.9  959.87  5425.7  958.50  5431.3  960.23  5465.7  961.29
#Mann=8,-1,0
  4300.0    0.12       0  4545.8    0.05       0  4629.1    0.12       0
  4804.5    0.05       0  4847.8    0.12       0  5006.2    0.07       0
  5025.1    0.12       0  5085.0    0.05       0
Bank Sta=5006.2,5025.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,8065,470,470,470
BEGIN DESCRIPTION:
WATERS CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2855955.67     10229103.10      2855801.75     10228882.00
      2855555.69     10228803.11
#Sta/Elev= 30
  4730.6  951.98  4738.0  953.19  4744.1  951.34  4767.1  949.03  4794.7  943.13
  4803.5  942.39  4809.6  940.12  4845.3  937.59  4860.2  937.70  4866.3  936.16
  4875.0  936.88  4902.1  933.50  4952.7  930.17  4967.5  928.01  4972.9  925.80
  4973.4  925.30  4991.8  925.80  5006.4  926.15  5017.4  929.20  5044.3  932.16
  5069.4  931.94  5108.6  937.06  5145.9  940.33  5178.1  945.35  5184.9  948.70
  5205.0  954.73  5210.2  951.09  5237.1  957.27  5242.3  955.56  5258.4  959.29
#Mann=3,-1,0
  4730.6    0.05       0  4972.9    0.05       0  4991.8    0.05       0
Bank Sta=4972.9,4991.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7595,489,489,489
BEGIN DESCRIPTION:
WATERS CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856255.67     10229053.07      2856147.75     10228587.00
      2856305.68     10228403.11
#Sta/Elev= 30
  4521.6  970.80  4593.4  960.62  4636.0  956.47  4665.3  955.98  4673.5  952.85
  4685.8  951.36  4706.3  951.05  4764.1  940.60  4873.9  931.95  4945.1  927.53
  4978.1  920.13  4978.6  919.63  4997.4  920.13  4999.4  922.31  5008.1  920.88
  5015.8  925.57  5022.4  924.47  5030.0  928.09  5036.6  926.15  5050.9  925.47
  5057.9  929.04  5079.4  934.48  5086.0  933.85  5093.7  938.00  5108.0  941.28
  5128.8  948.94  5143.1  950.87  5150.3  949.82  5178.7  950.23  5242.4  951.99
#Mann=6,-1,0
  4521.6    0.05       0  4873.9    0.12       0  4978.1    0.05       0
  4997.4    0.12       0  5150.3    0.12       0  5178.7    0.05       0
Bank Sta=4978.1,4997.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,7106,475,475,475
BEGIN DESCRIPTION:
WATERS CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856305.66     10229053.14      2856611.25     10228695.00
      2856755.71     10228553.09
#Sta/Elev= 30
  4529.2  971.49  4532.5  971.49  4537.0  969.79  4543.0  967.71  4557.2  964.66
  4583.7  960.24  4663.7  952.57  4720.8  948.83  4741.7  946.02  4819.6  939.06
  4827.3  939.05  4848.2  936.96  4870.2  938.70  4884.2  937.55  4954.7  923.02
  4962.4  921.12  4966.5  918.75  4967.0  918.25  4985.8  918.75  4997.5  919.66
  5015.9  919.63  5054.0  925.96  5075.2  928.65  5082.2  931.28  5089.4  932.46
  5110.5  938.17  5138.8  949.37  5167.1  957.67  5181.3  960.60  5202.5  962.15
#Mann=6,-1,0
  4529.2    0.05       0  4537.0    0.12       0  4583.7    0.05       0
  4966.5    0.05       0  4985.8    0.05       0  5015.9    0.12       0
Bank Sta=4966.5,4985.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6631,498,498,498
BEGIN DESCRIPTION:
WATERS CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856605.72     10229203.08      2856761.25     10229070.00
      2856905.68     10228903.12
#Sta/Elev= 30
  4795.3  941.75  4837.5  936.71  4845.2  934.57  4866.1  931.73  4880.3  929.06
  4908.9  921.48  4923.1  919.20  4944.0  914.50  4986.8  911.20  4993.4  912.05
  5005.4  911.13  5005.9  910.63  5024.8  911.13  5029.3  913.78  5035.9  915.61
  5072.1  917.34  5086.3  919.52  5092.9  921.30  5100.6  920.47  5107.2  921.99
  5114.8  921.49  5150.0  926.03  5156.6  928.55  5164.2  928.92  5170.8  930.81
  5178.5  931.09  5185.1  932.70  5207.0  933.55  5213.6  935.64  5220.7  935.32
#Mann=3,-1,0
  4795.3    0.05       0  5005.4    0.05       0  5024.8    0.05       0
Bank Sta=5005.4,5024.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6133,483,483,483
BEGIN DESCRIPTION:
WATERS CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856805.72     10229603.09      2856986.25     10229501.00
      2857155.69     10229353.11
#Sta/Elev= 30
  4792.6  938.91  4806.3  937.30  4822.2  934.13  4843.8  931.65  4859.7  928.32
  4865.4  928.20  4881.4  925.47  4918.9  920.95  4930.4  916.39  4940.5  913.63
  4946.3  913.02  4952.5  908.81  4953.0  908.31  4971.4  908.31  4971.9  908.81
  4983.8  909.65  4989.6  909.09  5005.1  909.67  5019.4  909.31  5083.0  916.21
  5097.2  917.20  5111.5  917.22  5154.2  921.48  5189.3  926.43  5196.9  928.27
  5203.5  928.54  5211.1  930.13  5217.8  930.32  5223.9  931.29  5224.9  931.29
#Mann=4,-1,0
  4792.6    0.12       0  4952.5    0.07       0  4971.9    0.12       0
  5223.9    0.05       0
Bank Sta=4952.5,4971.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5650,607,607,607
BEGIN DESCRIPTION:
WATERS CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2856955.71     10229853.12      2857258.00     10229898.00
      2857355.67     10229603.16
#Sta/Elev= 30
  4694.4  931.86  4706.0  930.28  4729.1  928.39  4734.8  927.03  4765.1  923.48
  4805.2  920.15  4856.1  916.84  4886.5  916.71  4906.7  915.30  4922.4  913.11
  4926.9  912.65  4932.3  911.02  4937.4  911.89  4957.2  908.07  4980.0  906.44
  4999.8  904.87  5000.3  904.37  5018.7  904.37  5019.2  904.87  5035.9  906.42
  5041.2  908.88  5047.3  910.55  5067.6  912.48  5078.9  914.63  5099.3  915.16
  5110.5  916.92  5142.1  919.81  5215.8  924.06  5226.0  924.00  5310.6  925.91
#Mann=8,-1,0
  4694.4    0.12       0  4706.0    0.05       0  4805.2    0.12       0
  4922.4    0.05       0  4980.0    0.12       0  4999.8    0.07       0
  5019.2    0.12       0  5226.0    0.05       0
Bank Sta=4999.8,5019.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5043,836,836,836
BEGIN DESCRIPTION:
Mapping XS 322fd0a8
END DESCRIPTION:
XS GIS Cut Line= 3
      2857449.10     10230821.88      2857589.72     10230358.36
      2857542.91     10229546.99
#Sta/Elev= 30
  4560.2  942.51  4590.3  942.45  4597.8  941.12  4603.0  941.90  4630.7  939.11
  4635.9  939.63  4668.8  935.98  4674.0  936.88  4701.7  933.25  4706.9  933.74
  4767.5  925.05  4772.7  925.85  4805.6  920.87  4810.9  922.03  4837.4  917.19
  4935.1  911.32  4947.7  909.63  4956.0  906.38  4966.5  904.22  4970.7  901.17
  4971.2  900.67  4990.4  901.17  5044.6  905.08  5059.9  907.44  5099.9  910.77
  5160.0  913.97  5200.7  915.01  5340.3  917.68  5552.2  918.06  5857.3  925.73
#Mann=5,-1,0
  4560.2    0.05       0  4837.4    0.12       0  4970.7    0.07       0
  4990.4    0.12       0  5200.7    0.05       0
Bank Sta=4970.7,4990.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4207,531,531,531
BEGIN DESCRIPTION:
WATERS CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2858255.69     10230553.16      2858155.00     10229942.00
      2858155.68     10229703.10
#Sta/Elev= 30
  4380.6  930.83  4408.7  927.95  4413.8  928.47  4421.2  926.62  4431.3  925.43
  4563.1  918.53  4653.3  915.50  4658.4  916.48  4714.5  913.88  4725.2  914.29
  4745.5  912.83  4826.6  909.88  4841.9  909.98  4847.0  908.67  4857.0  909.29
  4897.5  907.56  4903.1  906.78  4908.1  904.92  4954.0  899.34  4988.7  899.60
  5029.0  897.76  5029.5  897.26  5048.7  897.76  5078.9  907.53  5108.9  907.97
  5128.9  916.45  5148.9  922.98  5178.9  926.89  5208.9  928.81  5238.9  932.23
#Mann=4,-1,0
  4380.6    0.05       0  4954.0    0.12       0  5029.0    0.07       0
  5048.7    0.12       0
Bank Sta=5029,5048.7
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3676,532,532,532
BEGIN DESCRIPTION:
Mapping XS 66a36142
END DESCRIPTION:
XS GIS Cut Line= 4
      2858360.56     10230775.00      2858485.56     10230285.44
      2858662.64     10229889.61      2859037.65     10229384.38
#Sta/Elev= 30
  4164.1  932.20  4351.8  931.05  4496.3  918.49  4572.1  916.07  4891.0  910.28
  4928.1  907.30  4945.8  900.91  4957.9  894.00  4958.4  893.50  4977.6  894.00
  4997.7  894.40  5044.1  905.04  5096.0  910.66  5212.7  908.76  5296.4  906.48
  5317.2  901.58  5338.1  901.82  5350.9  904.76  5367.3  904.39  5373.5  906.20
  5381.9  904.12  5402.7  906.66  5417.4  911.61  5517.5  915.60  5553.0  914.47
  5578.8  917.95  5588.4  920.06  5603.0  919.53  5659.3  924.10  5732.2  926.53
#Mann=7,-1,0
  4164.1    0.05       0  4572.1    0.12       0  4957.9    0.07       0
  4977.6    0.12       0  5212.7    0.05       0  5350.9    0.12       0
  5578.8    0.05       0
Bank Sta=4957.9,4977.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3144,645,645,645
BEGIN DESCRIPTION:
WATERS CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2858855.68     10230853.11      2858883.00     10230435.00
      2859255.68     10230253.11
#Sta/Elev= 30
  4581.0  939.22  4701.3  928.65  4741.3  925.92  4761.4  922.40  4801.5  917.71
  4818.2  914.53  4831.5  912.52  4921.7  905.57  4941.8  901.54  4951.8  898.35
  4960.6  893.92  4971.8  891.67  4981.6  890.89  4982.1  890.39  5002.2  890.89
  5015.9  891.76  5034.7  895.24  5040.2  897.10  5047.5  901.15  5057.2  903.67
  5092.0  907.19  5130.3  908.04  5203.5  912.31  5220.4  912.13  5248.5  914.14
  5265.5  913.95  5312.5  916.14  5355.6  918.25  5406.2  922.04  5414.7  923.43
#Mann=6,-1,0
  4581.0    0.12       0  4818.2    0.05       0  4981.6    0.03       0
  5002.2    0.05       0  5015.9    0.12       0  5312.5    0.05       0
Bank Sta=4981.6,5002.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2499,425,425,425
BEGIN DESCRIPTION:
Mapping XS 4521410e
END DESCRIPTION:
XS GIS Cut Line= 3
      2859011.59     10231280.25      2859412.64     10230717.73
      2859511.59     10229952.15
#Sta/Elev= 30
  4189.0  933.71  4376.4  931.34  4563.2  918.07  4584.1  918.88  4598.9  916.82
  4619.8  918.00  4649.3  912.36  4703.3  909.80  4710.4  909.48  4771.0  905.58
  4799.6  910.69  4806.6  908.52  4827.5  911.52  4842.3  910.73  4857.0  907.62
  4884.7  906.07  4965.2  889.31  4995.2  887.04  4995.7  886.54  5015.9  887.04
  5035.8  891.62  5054.1  899.78  5066.0  903.36  5086.2  905.78  5192.5  909.69
  5327.9  916.59  5491.6  918.84  5571.0  922.19  5640.2  927.78  5651.8  927.05
#Mann=7,-1,0
  4189.0    0.05       0  4703.3    0.12       0  4710.4    0.05       0
  4995.2    0.05       0  5015.9    0.05       0  5054.1    0.12       0
  5192.5    0.05       0
Bank Sta=4995.2,5015.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2074,811,811,811
BEGIN DESCRIPTION:
Mapping XS 9dce06bc
END DESCRIPTION:
XS GIS Cut Line= 3
      2859574.11     10231280.19      2859782.43     10230811.48
      2860120.39     10230187.55
#Sta/Elev= 30
  4374.7  932.01  4480.9  933.80  4579.4  933.26  4699.8  927.60  4788.8  918.28
  4806.6  914.88  4919.9  905.34  4947.6  897.79  4954.0  893.57  4977.2  887.79
  4989.1  882.71  4989.6  882.21  5009.8  882.71  5022.2  888.13  5029.4  893.60
  5057.0  904.99  5079.1  908.86  5111.2  911.68  5182.7  913.23  5204.4  915.38
  5236.8  913.85  5368.0  918.16  5471.7  923.89  5477.3  925.95  5493.5  926.88
  5509.7  926.01  5515.4  927.85  5531.6  928.53  5537.3  930.84  5597.2  937.23
#Mann=5,-1,0
  4374.7    0.05       0  4977.2    0.12       0  4989.1    0.07       0
  5009.8    0.12       0  5182.7    0.05       0
Bank Sta=4989.1,5009.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1263,0,0,0
BEGIN DESCRIPTION:
WATERS CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2859865.73     10231488.58      2860418.66     10231229.89
      2860366.48     10230827.10
#Sta/Elev= 30
  4407.1  911.71  4478.9  909.86  4507.3  911.16  4615.9  906.62  4644.3  907.95
  4672.7  905.36  4690.0  901.81  4712.8  900.94  4741.2  902.91  4758.5  900.77
  4764.0  902.13  4781.3  900.76  4786.9  902.47  4804.2  899.78  4809.7  901.45
  4832.5  895.62  4838.0  897.06  4870.7  894.05  4914.9  884.83  5002.8  876.64
  5003.3  876.14  5023.5  876.64  5044.5  878.19  5079.7  888.75  5095.0  895.21
  5115.1  899.91  5153.9  902.53  5175.6  907.35  5233.2  908.66  5423.7  918.03
#Mann=3,-1,0
  4407.1    0.05       0  5002.8    0.05       0  5023.5    0.05       0
Bank Sta=5002.8,5023.5
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
