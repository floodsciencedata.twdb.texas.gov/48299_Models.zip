HEC-RAS study LOST HOLLOW CREEK.prj: LOST HOLLOW CREEK Base Level Engineering

--- LOST HOLLOW CREEK.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1,6903,543,543,543
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2811985.80     10174138.42      2811587.23     10173497.26
      2811390.41     10173168.52
#Sta/Elev= 30
  4326.6 1196.09  4352.9 1193.70  4410.7 1192.74  4520.3 1186.15  4568.9 1182.72
  4680.4 1179.32  4910.1 1173.62  4968.7 1166.34  5013.1 1164.32  5013.6 1161.32
  5026.3 1161.32  5026.8 1164.32  5037.2 1169.24  5044.8 1171.73  5056.5 1173.56
  5071.9 1178.59  5114.6 1179.48  5268.3 1194.63  5289.7 1193.96  5305.2 1196.79
  5311.0 1195.52  5326.6 1198.17  5348.0 1197.48  5363.6 1200.07  5369.4 1198.56
  5384.9 1200.70  5390.8 1199.63  5421.9 1201.89  5427.7 1200.72  5464.7 1204.22
#Mann=7,-1,0
  4326.6    0.05       0  4520.3    0.12       0  4680.4    0.05       0
  5013.1    0.05       0  5026.8    0.05       0  5037.2    0.12       0
  5044.8    0.05       0
Bank Sta=5013.1,5026.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6360,357,357,357
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 13.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2812233.18     10174149.23      2812144.21     10173500.37
      2812074.76     10172988.19
#Sta/Elev= 30
  4220.6 1191.80  4235.4 1189.67  4307.5 1186.68  4312.6 1185.58  4384.7 1183.31
  4428.7 1180.30  4606.2 1173.54  4678.3 1172.58  4771.8 1169.31  4882.9 1169.08
  4953.5 1165.42  4963.6 1164.65  4983.8 1161.20  4993.9 1161.48  5007.2 1159.87
  5007.7 1156.87  5020.5 1156.87  5021.0 1159.87  5084.7 1172.56  5116.4 1175.72
  5116.6 1175.75  5122.5 1176.57  5127.6 1175.38  5145.2 1176.18  5216.2 1181.29
  5266.3 1183.49  5316.0 1187.05  5337.0 1188.46  5377.3 1193.83  5392.4 1194.78
#Mann=7,-1,0
  4220.6    0.05       0  5007.2    0.03       0  5021.0    0.05       0
  5116.4    0.12       0  5116.6    0.05       0  5216.2    0.12       0
  5316.0    0.05       0
Bank Sta=5007.2,5021
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,6003,448,448,448
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2812521.81     10173969.15      2812473.67     10173209.28
      2812255.71     10173003.13
#Sta/Elev= 30
  4368.7 1186.87  4424.9 1182.67  4492.9 1181.16  4555.1 1178.81  4631.1 1178.09
  4655.3 1176.55  4681.8 1171.56  4735.5 1168.81  4875.8 1165.71  4965.9 1160.56
  4999.1 1155.94  4999.6 1152.94  5012.4 1152.94  5012.9 1155.94  5036.1 1164.78
  5066.1 1168.04  5154.4 1167.29  5203.8 1170.13  5218.0 1168.51  5291.5 1173.07
  5309.8 1176.91  5317.1 1176.91  5323.9 1179.63  5331.2 1179.42  5338.1 1181.85
  5345.4 1181.49  5352.3 1183.54  5359.5 1183.29  5380.6 1186.82  5430.1 1191.64
#Mann=7,-1,0
  4368.7    0.12       0  4492.9    0.05       0  4631.1    0.12       0
  4681.8    0.05       0  4999.1    0.05       0  5012.9    0.05       0
  5291.5    0.12       0
Bank Sta=4999.1,5012.9
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5555,349,349,349
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2813088.21     10173895.30      2812973.20     10173341.95
      2812455.67     10172953.10
#Sta/Elev= 30
  4354.8 1184.71  4510.2 1181.38  4612.4 1178.19  4877.9 1174.84  4920.0 1173.38
  4945.6 1172.08  4953.9 1168.01  4960.1 1168.06  4966.9 1161.69  4981.0 1155.55
  5003.2 1152.75  5003.7 1149.75  5016.6 1149.75  5017.1 1152.75  5024.7 1154.87
  5039.3 1156.36  5045.5 1158.81  5074.7 1160.83  5081.0 1163.22  5103.9 1162.68
  5117.0 1164.27  5195.5 1164.69  5245.5 1166.15  5260.1 1165.25  5324.6 1165.30
  5495.4 1166.54  5530.8 1167.99  5553.7 1170.05  5560.0 1171.66  5567.3 1171.57
#Mann=3,-1,0
  4354.8    0.05       0  5003.2    0.05       0  5017.1    0.05       0
Bank Sta=5003.2,5017.1
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,5206,480,480,480
BEGIN DESCRIPTION:
Mapping XS 726be8ed
END DESCRIPTION:
XS GIS Cut Line= 5
      2813148.98     10173467.77      2813183.70     10173018.60
      2812385.09     10172792.90      2812389.43     10172795.07
      2812265.77     10172782.05
#Sta/Elev= 30
  4420.2 1175.36  4483.4 1174.02  4645.5 1171.93  4775.9 1167.70  4831.3 1164.13
  4931.0 1162.29  4946.3 1158.11  4951.8 1154.52  4962.2 1151.17  4978.5 1150.04
  4979.0 1147.04  4991.9 1147.04  4992.4 1150.04  4993.4 1151.38  5003.7 1151.19
  5053.4 1159.67  5058.6 1159.25  5092.6 1162.98  5126.6 1165.33  5351.2 1163.39
  5536.6 1165.56  5616.9 1168.34  5668.8 1172.05  5689.6 1170.33  5709.9 1170.37
  5759.5 1175.62  5768.2 1177.74  5773.3 1176.12  5789.7 1179.53  5829.8 1181.62
#Mann=4,-1,0
  4420.2    0.12       0  4483.4    0.05       0  4978.5    0.05       0
  4992.4    0.05       0
Bank Sta=4978.5,4992.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4726,517,517,517
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2813318.25     10173088.07      2813296.55     10172701.75
      2813244.46     10172259.03
#Sta/Elev= 30
  4495.3 1166.35  4550.3 1164.05  4560.4 1162.32  4585.5 1160.78  4620.5 1160.38
  4700.6 1162.14  4710.6 1163.16  4780.7 1163.06  4820.8 1160.46  4850.8 1160.41
  4890.9 1158.74  4911.1 1156.77  4941.3 1152.15  4951.3 1152.18  4971.5 1147.12
  4981.6 1147.46  4984.6 1146.60  4985.1 1143.60  4998.1 1143.60  4998.6 1146.60
  5001.7 1146.87  5011.8 1150.00  5017.4 1160.16  5022.4 1157.04  5031.9 1163.23
  5042.0 1166.60  5052.0 1169.24  5062.1 1170.10  5105.5 1170.30  5328.0 1166.98
#Mann=4,-1,0
  4495.3    0.12       0  4585.5    0.05       0  4984.6    0.05       0
  4998.6    0.05       0
Bank Sta=4984.6,4998.6
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,4209,518,518,518
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814186.29     10172994.70      2813865.13     10172706.10
      2813379.87     10172320.49
#Sta/Elev= 30
  4461.1 1174.17  4504.9 1173.41  4673.8 1166.68  4745.6 1165.26  4831.1 1165.64
  4880.2 1165.53  4930.5 1162.38  4937.4 1161.34  4966.2 1151.72  4987.0 1143.77
  4987.2 1142.86  4987.7 1139.86  5001.0 1139.86  5001.5 1142.86  5022.3 1144.29
  5036.7 1147.56  5080.0 1147.85  5100.8 1151.35  5108.8 1151.60  5122.1 1155.10
  5150.4 1159.27  5193.7 1159.25  5228.9 1157.38  5278.6 1159.29  5313.8 1158.86
  5357.1 1161.33  5385.9 1164.54  5416.4 1165.23  5471.5 1165.98  5512.7 1165.63
#Mann=7,-1,0
  4461.1    0.12       0  4673.8    0.05       0  4831.1    0.12       0
  4987.2    0.05       0  5001.5    0.12       0  5416.4    0.12       0
  5471.5    0.05       0
Bank Sta=4987.2,5001.5
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3691,399,399,399
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814474.98     10172159.22      2814064.78     10172150.54
      2813290.32     10172131.02
#Sta/Elev= 30
  4429.4 1170.90  4477.8 1169.26  4545.7 1168.65  4738.8 1159.52  4888.8 1154.90
  4928.8 1151.19  4934.9 1148.39  4939.9 1148.10  4958.8 1141.54  4978.8 1138.59
  4981.9 1139.01  4988.8 1139.93  4991.6 1137.69  4992.1 1134.69  5005.5 1134.69
  5006.0 1137.69  5018.8 1141.19  5028.8 1145.30  5048.9 1147.93  5068.9 1154.18
  5088.9 1156.67  5198.9 1155.17  5228.9 1156.63  5268.9 1156.25  5298.9 1157.65
  5359.0 1158.27  5429.0 1160.89  5509.0 1160.15  5529.0 1161.12  5614.4 1161.26
#Mann=5,-1,0
  4429.4    0.05       0  4545.7    0.12       0  4981.9    0.05       0
  4991.6    0.05       0  5006.0    0.05       0
Bank Sta=4991.6,5006
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,3292,346,346,346
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814398.95     10171792.46      2813734.92     10171731.70
      2813529.69     10171535.11
#Sta/Elev= 30
  4521.4 1176.81  4574.9 1171.70  4584.9 1171.64  4665.3 1162.53  4679.6 1163.02
  4735.6 1158.61  4772.8 1157.65  4789.7 1156.45  4846.0 1155.98  4906.3 1153.59
  4926.3 1150.58  4940.0 1146.69  4986.6 1137.65  4989.4 1135.78  4989.9 1132.78
  5003.3 1132.78  5003.8 1135.78  5016.7 1137.46  5026.8 1137.54  5036.8 1141.04
  5046.8 1150.44  5056.9 1154.29  5087.0 1154.41  5147.3 1151.98  5229.0 1150.59
  5243.1 1151.41  5250.3 1152.93  5278.6 1154.06  5363.6 1154.38  5472.4 1159.26
#Mann=5,-1,0
  4521.4    0.05       0  4772.8    0.12       0  4940.0    0.05       0
  4989.4    0.05       0  5003.8    0.05       0
Bank Sta=4989.4,5003.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2946,389,389,389
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814470.61     10171571.12      2814057.10     10171409.33
      2813655.68     10171403.11
#Sta/Elev= 30
  4398.7 1165.40  4425.5 1163.80  4432.6 1165.54  4438.0 1163.57  4462.4 1164.36
  4468.4 1165.32  4492.3 1164.23  4532.8 1164.21  4546.6 1163.04  4565.1 1163.06
  4576.4 1161.37  4624.3 1158.60  4649.8 1158.30  4709.4 1153.93  4769.1 1150.72
  4812.0 1151.02  4824.2 1150.26  4845.9 1149.02  4874.2 1144.28  4934.2 1142.52
  4997.0 1134.24  4997.5 1131.24  5010.9 1131.24  5011.4 1134.24  5034.2 1139.47
  5054.2 1147.82  5064.2 1150.17  5144.2 1148.39  5174.2 1150.22  5244.2 1157.05
#Mann=5,-1,0
  4398.7    0.05       0  4624.3    0.12       0  4824.2    0.05       0
  4997.0    0.05       0  5011.4    0.05       0
Bank Sta=4997,5011.4
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,2557,609,609,609
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814492.27     10171132.74      2813808.70     10170996.03
      2813599.48     10171205.25
#Sta/Elev= 30
  4427.4 1163.84  4515.7 1157.52  4545.1 1156.52  4597.3 1153.84  4603.2 1154.34
  4617.7 1153.06  4638.1 1152.93  4659.3 1150.70  4705.2 1148.30  4744.8 1148.10
  4770.7 1147.98  4807.1 1142.51  4831.8 1141.11  4872.6 1140.36  4923.6 1137.73
  4954.2 1137.17  4984.8 1132.06  4987.8 1130.85  4988.3 1127.85  5001.7 1127.85
  5002.2 1130.85  5011.1 1133.29  5016.2 1133.65  5025.6 1143.86  5035.8 1147.28
  5202.4 1147.80  5258.9 1148.68  5315.5 1148.23  5365.0 1149.91  5420.4 1153.32
#Mann=5,-1,0
  4427.4    0.05       0  4545.1    0.12       0  4744.8    0.05       0
  4987.8    0.05       0  5002.2    0.05       0
Bank Sta=4987.8,5002.2
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1948,495,495,495
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814696.27     10171052.43      2814353.41     10170555.49
      2813834.77     10170305.93
#Sta/Elev= 30
  4272.1 1170.97  4344.2 1165.70  4372.3 1165.04  4545.4 1154.22  4705.6 1147.71
  4805.0 1144.08  4840.8 1143.99  4846.9 1142.54  4861.8 1143.82  4874.3 1142.87
  4931.7 1143.65  4964.8 1143.91  4973.2 1140.05  4987.5 1129.55  4997.4 1127.61
  4997.9 1124.61  5011.3 1124.61  5011.8 1127.61  5017.6 1130.54  5032.7 1132.04
  5039.0 1131.47  5055.4 1131.62  5072.4 1135.23  5184.0 1138.33  5228.4 1143.67
  5253.7 1142.57  5272.8 1139.91  5287.2 1140.52  5406.0 1152.58  5451.4 1153.42
#Mann=7,-1,0
  4272.1    0.05       0  4705.6    0.12       0  4931.7    0.05       0
  4997.4    0.05       0  5011.8    0.05       0  5039.0    0.12       0
  5253.7    0.05       0
Bank Sta=4997.4,5011.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1453,391,391,391
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2814765.74     10170562.02      2814470.59     10170021.63
      2814344.73     10169939.17
#Sta/Elev= 30
  4505.3 1154.77  4510.5 1154.28  4511.1 1154.18  4534.6 1152.00  4600.1 1150.99
  4616.2 1148.70  4662.8 1145.76  4807.0 1138.09  4872.4 1139.90  4888.6 1135.39
  4894.3 1136.06  4902.9 1133.94  4919.8 1132.78  4959.8 1128.22  4975.9 1129.00
  4990.3 1124.77  4990.8 1121.77  5004.5 1121.77  5005.0 1124.77  5005.4 1126.62
  5041.3 1131.55  5101.1 1131.96  5117.2 1136.18  5124.2 1136.42  5130.2 1139.39
  5145.3 1140.10  5151.2 1143.02  5166.3 1145.57  5223.6 1149.35  5271.5 1150.80
#Mann=7,-1,0
  4505.3    0.05       0  4510.5    0.12       0  4511.1    0.05       0
  4662.8    0.12       0  4919.8    0.05       0  4990.3    0.05       0
  5005.0    0.05       0
Bank Sta=4990.3,5005
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,1062,434,434,434
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2815037.02     10170208.30      2814809.14     10169861.04
      2814461.88     10169630.99
#Sta/Elev= 30
  4723.4 1151.28  4741.6 1152.76  4761.2 1152.32  4771.4 1152.21  4786.5 1149.81
  4792.5 1150.31  4801.4 1149.46  4822.7 1146.59  4843.8 1142.28  4899.7 1136.82
  4916.1 1133.24  4931.2 1131.38  4958.3 1130.18  4980.8 1126.36  4981.1 1123.19
  4981.6 1120.19  4995.3 1120.19  4995.8 1123.19  5016.7 1126.89  5060.8 1126.68
  5066.8 1127.70  5088.4 1128.14  5118.0 1134.15  5176.9 1135.59  5233.7 1134.91
  5363.1 1137.00  5378.1 1138.44  5442.8 1141.13  5501.5 1147.96  5555.3 1150.02
#Mann=6,-1,0
  4723.4    0.05       0  4761.2    0.12       0  4899.7    0.05       0
  4981.1    0.07       0  4995.8    0.05       0  5176.9    0.05       0
Bank Sta=4981.1,4995.8
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1,628,0,0,0
BEGIN DESCRIPTION:
LOST HOLLOW CREEK 1.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2815156.35     10169945.70      2815225.80     10169665.73
      2814605.69     10169453.12
#Sta/Elev= 30
  4577.9 1146.06  4678.7 1139.62  4683.9 1140.94  4766.6 1138.28  4802.8 1134.09
  4808.0 1135.97  4858.7 1137.82  4865.1 1136.21  4877.1 1136.57  4891.4 1134.73
  4940.5 1126.00  4948.6 1125.94  4961.6 1122.71  4993.3 1122.09  4996.6 1120.36
  4997.1 1117.36  5010.8 1117.36  5011.3 1120.36  5025.1 1125.61  5042.5 1128.78
  5067.3 1128.96  5117.1 1132.85  5130.8 1134.73  5198.8 1135.46  5292.6 1135.29
  5323.9 1133.35  5373.9 1133.87  5437.3 1136.22  5467.4 1140.71  5521.9 1146.66
#Mann=5,-1,0
  4577.9    0.05       0  4996.6    0.05       0  5011.3    0.05       0
  5117.1    0.12       0  5467.4    0.05       0
Bank Sta=4996.6,5011.3
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
