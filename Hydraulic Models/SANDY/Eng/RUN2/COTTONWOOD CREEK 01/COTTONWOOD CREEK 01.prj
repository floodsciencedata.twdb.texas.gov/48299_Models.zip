HEC-RAS study COTTONWOOD CREEK 01.prj: COTTONWOOD CREEK 01 Base Level Engineering

--- COTTONWOOD CREEK 01.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,11648   ,322,322,322
BEGIN DESCRIPTION:
Mapping XS 98abe753
END DESCRIPTION:
XS GIS Cut Line= 5
      2864651.45     10179922.87      2864441.47     10179502.91
      2864244.75     10179332.67      2864248.53     10179332.67
      2864116.14     10179222.97
#Sta/Elev= 30
  4593.8 1036.57  4658.8 1034.63  4724.4 1031.15  4843.3 1024.37  4882.4 1018.51
    4888 1016.07  4904.8 1016.12  4910.4 1013.72  4927.1 1012.11  4949.5 1006.97
  4977.4 1004.34  5004.1 1000.56  5004.6 1000.06  5010.4 1000.56  5022.2  1001.9
  5038.9 1007.71  5067.5 1009.85  5145.4 1014.48  5180.5 1014.42  5237.5 1018.08
  5258.4 1018.39  5319.6 1025.53  5330.8 1025.53  5343.8 1027.04  5385.4 1033.92
  5393.3 1034.06  5399.7 1035.91  5457.1 1040.95  5494.8 1045.28  5499.2 1045.72
#Mann= 5 ,-1 , 0
  4593.8     .05       0  4724.4     .12       0  5004.1     .07       0
  5010.4     .12       0  5494.8     .05       0
Bank Sta=5004.1,5010.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,11326   ,351,351,351
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 25.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2864914.33     10179561.52      2864649.54     10179287.27
      2864324.17     10179124.58
#Sta/Elev= 30
  4726.5 1036.03  4736.5 1035.55  4745.6 1035.36  4759.8 1034.04  4766.7 1032.64
  4868.3 1023.54  4908.2 1019.97  4922.4 1016.02  4957.9 1009.66  4964.8 1005.56
    4972 1002.42    4979 1000.97    4983  998.31  4983.5  997.81  4989.3  998.31
  5007.3  999.71  5021.4 1003.14  5042.8 1005.35    5078 1007.01    5190 1008.67
    5218  1009.8  5223.8  1010.7  5255.2 1011.92  5307.4 1014.11  5346.5 1018.16
  5368.9 1021.17  5380.4 1023.46    5436 1028.13  5458.6 1030.95  5471.5 1032.37
#Mann= 8 ,-1 , 0
  4726.5     .12       0  4736.5     .05       0  4868.3     .12       0
    4983     .07       0  4989.3     .12       0    5218     .05       0
  5255.2     .12       0  5458.6     .05       0
Bank Sta=4983,4989.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10975   ,161,161,161
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 24.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865025.95     10179387.49      2864955.97     10179122.71
      2864517.12     10178810.59
#Sta/Elev= 30
  4603.7 1025.27  4664.3 1023.01  4773.7 1013.63  4790.5 1011.41  4866.8 1004.48
  4899.5 1002.65  4905.7 1002.93  4914.3 1001.88  4941.3 1001.24  4970.9  999.25
  4985.6  997.85  4991.8  996.65  4997.2  994.64  4997.7  994.14  5003.6  994.64
  5006.5  997.67  5021.3  999.77  5027.4  1003.5  5049.7 1004.96  5117.1 1006.53
  5128.3 1006.94  5157.8 1010.26  5163.9 1010.04  5184.8 1011.53  5270.9 1022.22
  5286.2  1023.2  5315.2 1025.07  5321.3 1026.52    5330 1026.31  5416.1 1030.26
#Mann= 6 ,-1 , 0
  4603.7     .05       0  4790.5     .12       0  4997.2     .07       0
  5003.6     .12       0  5117.1     .05       0  5286.2     .12       0
Bank Sta=4997.2,5003.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10814   ,379,379,379
BEGIN DESCRIPTION:
Mapping XS dd123864
END DESCRIPTION:
XS GIS Cut Line= 3
      2865101.61     10179270.21      2865024.06     10178978.95
      2864689.95     10178729.78
#Sta/Elev= 30
  4603.9 1017.92  4714.7  1014.8  4741.7 1012.12  4762.1 1010.43  4767.3 1009.18
  4776.8 1008.68  4807.9 1004.32  4842.4 1002.15  4877.3 1000.99  4900.6 1001.77
  4922.7 1001.06  4951.9 1001.47  4965.7  999.09  4972.8  995.88    4979  994.56
  4990.4  994.25  4990.9  993.75  4996.3  993.75  4996.8  994.25  5008.2  996.44
  5015.6   999.3  5022.8 1000.97    5029  999.57  5058.2 1002.16  5065.5 1002.25
  5094.7 1005.84  5152.1 1010.99    5273 1025.69  5308.4 1028.56  5322.1 1028.64
#Mann= 5 ,-1 , 0
  4603.9     .05       0  4741.7     .12       0  4990.4     .07       0
  4996.8     .12       0  5094.7     .05       0
Bank Sta=4990.4,4996.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10435   ,317,317,317
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 23.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865555.71     10179003.14      2865199.98     10178653.61
      2864795.19     10178551.46
#Sta/Elev= 30
  4549.1 1030.69  4565.3 1028.77  4605.7 1025.91  4641.1 1021.52  4711.9 1016.34
  4775.4 1012.42  4846.1 1006.66  4860.2 1006.63  4902.7 1002.34  4923.9  998.77
  4938.1  997.63  4973.4  992.51  4984.2  992.39  4984.7  991.89  4990.8  992.39
  5001.7  993.32  5015.8  996.75    5023  997.53  5113.1  999.21  5186.3 1000.47
  5192.2  1001.3  5197.3 1000.29  5268.8 1004.73  5299.8 1008.34  5315.4 1011.53
  5356.4 1015.82  5361.7 1017.58  5402.9 1024.64  5444.2  1027.8  5465.3 1028.42
#Mann= 6 ,-1 , 0
  4549.1     .12       0  4565.3     .05       0  4711.9     .12       0
  4984.2     .07       0  4990.8     .12       0  5113.1     .05       0
Bank Sta=4984.2,4990.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,10118   ,221,221,221
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 22.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865655.66     10178653.09      2865392.91     10178385.01
      2864942.72     10178349.07
#Sta/Elev= 30
  4493.8  1023.1  4587.8 1015.55  4691.7 1006.62    4710  1005.9  4722.9 1004.25
  4748.3 1002.17  4826.2  997.89  4840.3  997.57  4847.3  997.96    4867   996.9
  4946.6  996.53  4958.8  996.02  4966.7  995.46  4976.7   992.2  4986.8  990.36
  4993.5  990.18    4994  989.68  4999.6  989.68  5000.1  990.18  5026.9  993.39
  5040.3  993.88    5057  994.12  5107.2  997.43  5117.2  998.53  5147.3 1000.08
  5157.3 1001.62  5197.4 1005.37  5267.7 1014.84  5297.8 1017.21  5320.8 1018.16
#Mann= 7 ,-1 , 0
  4493.8     .05       0  4587.8     .12       0    4710     .05       0
  4722.9     .12       0  4993.5     .07       0  5000.1     .12       0
  5040.3     .05       0
Bank Sta=4993.5,5000.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9897    ,222,222,222
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 21.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2865705.67      10178453.1        2865374.     10178193.96
      2865122.44     10178063.45
#Sta/Elev= 30
  4509.4 1014.62    4560 1011.58  4644.6 1004.65  4659.5 1003.64    4687  999.91
  4723.7  997.13  4765.3  995.81  4837.7  994.75  4872.9  995.78  4893.8  995.13
  4915.5  995.34  4926.9  994.28  4938.5  994.64  4944.2   993.9  4960.6  993.69
  4973.5  991.52    4996  989.96  5015.2  989.96  5015.7  989.46  5021.3  989.46
  5021.8  989.96    5027  992.74  5059.9  998.26  5076.9 1000.79  5093.4 1002.21
    5099 1002.05  5121.1 1004.99  5131.2 1005.17  5165.4 1008.68  5213.7 1010.99
#Mann= 5 ,-1 , 0
  4509.4     .05       0  4644.6     .12       0  5015.2     .07       0
  5021.8     .12       0  5059.9     .05       0
Bank Sta=5015.2,5021.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9675    ,257,257,257
BEGIN DESCRIPTION:
Mapping XS e84fcacc
END DESCRIPTION:
XS GIS Cut Line= 3
      2865786.32     10178407.68      2865521.54     10178156.13
      2865430.76     10177862.99
#Sta/Elev= 30
  4525.7 1014.19  4536.5 1014.04  4571.7 1011.77    4579 1011.85  4585.9 1010.64
  4614.2 1007.96  4642.5 1006.23  4663.9 1003.99    4685 1002.94  4720.2  999.56
  4775.9  996.22  4812.4  994.62  4840.7  993.84  4854.9  994.02  4861.8  993.45
  4961.8  993.26  4967.4  992.92  4977.8  990.95  4988.3  987.63  4991.1  985.44
  4991.6  984.94  4997.2  984.94  4997.7  985.44  4999.6  986.15  5009.2  986.54
  5064.8  993.24    5072  995.19  5100.4  999.96  5162.6 1005.51  5197.8 1006.13
#Mann= 5 ,-1 , 0
  4525.7     .05       0  4775.9     .12       0  4991.1     .07       0
  4997.7     .12       0  5100.4     .05       0
Bank Sta=4991.1,4997.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9418    ,323,323,323
BEGIN DESCRIPTION:
Mapping XS 7d6348e2
END DESCRIPTION:
XS GIS Cut Line= 3
      2865863.92     10178345.33      2865701.23     10177883.75
      2865450.25     10177808.27
#Sta/Elev= 30
  4615.4 1012.35  4629.4 1012.21    4686 1009.63  4734.4 1006.18  4769.8 1002.86
    4798 1000.16  4809.8  998.28  4835.4  995.58    4851  995.19  4861.1  994.06
  4882.8     993  4897.3  993.06    4904  992.33  4967.6  991.27  4978.3  990.23
  4984.8   986.9  4996.2  984.24  4996.7  983.74  5002.3  983.74  5002.8  984.24
  5015.8  984.83  5031.3   989.5  5046.7  990.96  5110.6  992.39  5182.5  995.18
    5215  998.48  5229.6  999.16  5288.1 1004.09  5340.3 1006.66  5366.9 1007.39
#Mann= 5 ,-1 , 0
  4615.4     .05       0  4769.8     .12       0  4996.2     .07       0
  5002.8     .12       0  5182.5     .05       0
Bank Sta=4996.2,5002.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,9095    ,277,277,277
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 20.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866302.76     10177934.83      2865833.64     10177734.32
      2865483.75     10177743.77
#Sta/Elev= 30
  4669.9  1012.2    4732 1012.96  4790.3 1007.75  4831.9 1003.01  4842.9  1001.7
  4861.1 1000.82  4866.5     999  4890.1  995.87  4960.4  988.69  4966.3  987.57
  4978.8  981.57  4979.3  981.07    4985  981.07  4985.5  981.57  4989.9  983.83
  5003.9  984.52  5013.5  985.92  5025.6  989.45    5048  989.27  5095.2  990.14
  5101.7   989.4  5124.2  990.58    5169  990.09  5258.1  990.55  5288.1  992.18
  5321.8  993.21  5358.1  997.68  5458.1 1006.41  5478.1 1007.23  5530.1 1007.93
#Mann= 5 ,-1 , 0
  4669.9     .05       0  4831.9     .12       0  4978.8     .07       0
  4985.5     .12       0    5169     .05       0
Bank Sta=4978.8,4985.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8818    ,384,384,384
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 19.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866355.68     10177553.11      2865727.99     10177556.71
      2865555.72     10177653.09
#Sta/Elev= 30
  4759.9 1006.28  4790.3 1003.35  4829.9  999.23  4839.9  999.05  4889.9  993.01
  4899.9   993.2  4959.9  987.45  4969.9   985.9  4986.6  982.01  4987.1  981.51
  4993.3  982.01  5009.9  982.89  5029.9  987.07  5039.9  987.88  5099.9  987.86
  5109.9  988.41  5129.9  986.81  5189.9  986.63  5300.3  987.59  5379.9  990.22
  5393.2  991.29  5409.2  994.18  5436.6  997.18  5452.6  997.77    5459  999.53
  5481.9 1001.12  5490.3 1002.92    5496 1002.54  5577.1 1005.77    5585 1006.68
#Mann= 5 ,-1 , 0
  4759.9     .05       0  4790.3     .12       0  4986.6     .07       0
  4993.3     .12       0  5300.3     .05       0
Bank Sta=4986.6,4993.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8434    ,286,286,286
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 18.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866255.68     10177203.11      2865992.61     10177191.49
      2865565.03     10177524.37
#Sta/Elev= 30
  4633.2 1012.46  4647.2 1011.48  4683.2 1006.98  4723.3 1003.74  4742.4 1000.46
  4747.4 1000.32  4753.3  998.76  4773.3  996.51  4843.4  986.29  4853.4  985.36
  4903.1  983.52  4967.4  982.51  4988.2  977.09  5005.6  975.86  5006.1  975.36
  5011.8  975.36  5012.3  975.86  5031.6  982.77  5037.9  983.59  5095.4   983.7
  5137.5  984.53  5145.6  985.23  5151.9  984.79  5194.9  987.38  5259.6  990.17
  5280.4  992.23  5294.9  992.46    5380  998.46  5414.9   999.2  5438.4  999.85
#Mann= 6 ,-1 , 0
  4633.2     .05       0  4647.2     .12       0  5005.6     .07       0
  5012.3     .12       0  5194.9     .05       0  5414.9     .12       0
Bank Sta=5005.6,5012.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,8148    ,469,469,469
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 17.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866378.45     10177134.72      2866062.52     10176998.51
       2865170.2     10176973.93
#Sta/Elev= 30
  4407.1 1014.08  4472.2 1011.03  4477.6 1009.64  4495.7 1008.98  4550.2 1004.97
  4595.2 1001.79  4606.1   999.5  4653.1  992.87  4660.6  990.49  4671.2  988.59
  4676.6  986.64    4715  981.18    4778   979.5    4828  980.12    4868  979.21
    4888  980.12    4938  980.23  4958.1  978.64  4978.1  975.56  5004.5   974.9
    5005   974.4  5011.7   974.9  5028.1  978.46  5056.6  981.95  5098.1  985.11
  5118.1  985.88  5308.2  991.24  5438.2  996.31  5548.3 1002.37  5643.8 1006.61
#Mann= 5 ,-1 , 0
  4407.1     .05       0  4550.2     .12       0  5004.5     .07       0
  5011.7     .12       0  5056.6     .05       0
Bank Sta=5004.5,5011.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7679    ,209,209,209
BEGIN DESCRIPTION:
Mapping XS fcce5e7c
END DESCRIPTION:
XS GIS Cut Line= 3
      2866425.71     10177093.11      2866041.71     10176667.49
      2865529.95     10176518.31
#Sta/Elev= 30
  4582.2 1012.38  4623.3 1009.49  4646.1 1006.93  4695.4 1004.13  4759.9  998.97
    4809   996.3  4813.3  995.42  4898.7  988.84  4929.3  985.54  4936.1  983.24
  4943.5  983.24  4950.3  980.64  4964.5  977.34  4978.4  976.23  4986.1  971.78
    4996  971.11  4996.5  970.61  5003.4  971.11  5007.1  972.18  5042.2  975.77
  5109.4  977.82  5289.7  982.73  5307.5  982.72  5393.4  987.37  5463.8  990.19
  5484.6  991.89  5510.6  992.36  5536.7  994.72  5640.9 1000.33  5688.5 1004.31
#Mann= 11 ,-1 , 0
  4582.2     .05       0  4623.3     .12       0  4759.9     .05       0
  4813.3     .12       0  4898.7     .05       0  4978.4     .12       0
    4996     .07       0  5003.4     .12       0  5109.4     .05       0
  5289.7     .12       0  5393.4     .05       0
Bank Sta=4996,5003.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7470    ,431,431,431
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 16.0
END DESCRIPTION:
XS GIS Cut Line= 4
      2866584.55     10176845.26      2866350.03      10176642.9
      2866094.67     10176540.76      2865661.47     10176291.05
#Sta/Elev= 30
  4574.5 1005.06  4717.4  994.28  4759.2  992.45  4787.7   989.5    4920  981.14
  4949.6  978.16    4955  976.56  4973.5  975.35  4979.2   974.6  4985.9  971.23
  5014.5  970.98    5015  970.48  5021.4  970.48  5021.9  970.98  5033.1  971.44
  5057.3  975.19  5062.7  974.76  5081.5  975.69  5106.7  975.46  5185.8  977.41
  5295.3  981.65  5334.2  983.32  5480.3  991.45  5517.7  994.74  5546.7  997.12
  5582.3 1000.82    5588    1002  5603.8  1002.7    5654 1008.22  5659.3 1008.22
#Mann= 9 ,-1 , 0
  4574.5     .12       0  4973.5     .05       0  5014.5     .05       0
  5021.9     .05       0  5106.7     .12       0  5295.3     .05       0
  5334.2     .12       0  5517.7     .05       0  5546.7     .12       0
Bank Sta=5014.5,5021.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,7039    ,404,404,404
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 15.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866605.71     10176603.14      2866227.25       10176180.
      2865805.66     10175903.09
#Sta/Elev= 30
  4432.3  991.48  4453.7  988.77  4500.6  986.37    4574   979.6  4654.4  977.76
  4765.4  976.66  4779.7  975.78  4786.4   976.3  4892.2  973.13  4916.5  972.27
  4935.2  971.28  4970.3  967.69  4993.7  966.92  4994.2  966.42  5001.1  966.92
  5013.8  967.81  5020.7  971.42    5047  974.07    5078  978.01  5093.1  978.76
  5114.1  982.11  5165.4  987.62  5265.1  995.78  5273.9  995.71  5294.9  998.08
  5337.1 1005.68  5382.4  1010.1  5401.1 1013.23  5468.5 1020.55  5504.4 1026.68
#Mann= 9 ,-1 , 0
  4432.3     .12       0  4500.6     .05       0  4654.4     .12       0
  4892.2     .05       0  4916.5     .12       0  4993.7     .07       0
  5001.1     .12       0    5047     .05       0  5401.1     .12       0
Bank Sta=4993.7,5001.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6635    ,393,393,393
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 14.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2866942.09     10176616.43      2866455.68     10175803.11
      2866132.54     10175725.51
#Sta/Elev= 30
  4174.6  998.36  4180.8  998.28  4251.1   990.6  4291.7  988.35  4364.9  982.46
  4512.4  977.48  4697.7  973.37  4853.9  971.02  4889.2   972.6  4896.6  971.38
  4902.5  971.81    4928  969.76  4960.8  967.73  4976.4  964.19    5002  961.94
  5002.5  961.44  5009.5  961.94  5028.9  968.08  5040.7  973.11  5050.3   975.3
  5056.1   978.2    5064  979.63  5077.5  986.58    5099  991.11  5114.5  992.11
  5182.7  992.79  5235.4  991.18  5271.8  993.67  5379.4  998.39  5454.6 1001.81
#Mann= 8 ,-1 , 0
  4174.6     .12       0  4251.1     .05       0  4512.4     .12       0
  4697.7     .05       0    4928     .12       0    5002     .07       0
  5009.5     .12       0  5379.4     .12       0
Bank Sta=5002,5009.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,6242    ,609,609,609
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 13.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867161.52     10176442.44      2866783.19     10175555.27
      2866603.53     10175369.93
#Sta/Elev= 30
  4165.6  989.89  4204.6  987.85  4239.9  986.35  4245.3  987.21  4268.9   983.9
  4360.6  979.79  4426.9  975.18  4478.2  973.57  4643.2  971.78  4674.9  970.57
  4790.2  969.66  4884.7  969.31  4947.4  966.04  4998.2  960.88  4998.7  960.38
  5005.8  960.88  5013.6  962.21  5031.8  961.75  5045.4  966.59  5075.9   968.5
  5165.2  974.68  5292.5  988.81  5299.7  990.31  5306.6   989.2  5313.8  991.21
  5320.8   990.6    5328  992.96  5334.9  993.56  5349.1  996.87  5388.2  999.84
#Mann= 9 ,-1 , 0
  4165.6     .05       0  4204.6     .12       0  4478.2     .05       0
  4674.9     .12       0  4790.2     .05       0  4947.4     .12       0
  4998.2     .07       0  5005.8     .12       0  5075.9     .05       0
Bank Sta=4998.2,5005.8
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5633    ,263,263,263
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 12.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867641.97     10176098.17      2867449.02      10175636.6
      2867305.67     10175153.08
#Sta/Elev= 30
  4372.1  978.29  4432.2  975.27  4609.7  969.56  4638.9  967.92  4648.5  968.22
  4670.2   967.1  4695.9  967.54  4832.8  965.49  4871.6  963.48  4939.7   961.5
  4973.6  960.03  4980.3  958.94  4990.7  955.82  4997.2  955.14  4997.7  954.64
  5005.2  955.14  5006.8  955.86  5032.5  956.63  5063.8  956.26  5078.5  959.12
  5084.6  962.55  5111.7  963.93    5117  964.92  5150.2  966.14  5168.1  965.78
  5209.8  967.44  5282.8  974.42  5288.4  976.03  5345.4  982.49  5376.7  984.42
#Mann= 5 ,-1 , 0
  4372.1     .05       0  4695.9     .12       0  4939.7     .05       0
  4997.2     .05       0  5005.2     .05       0
Bank Sta=4997.2,5005.2
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5370    ,230,230,230
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 11.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867921.89      10175901.4      2867723.29      10175481.5
      2867405.69     10175103.12
#Sta/Elev= 30
  4388.5  982.05  4410.6  981.17  4437.2  981.06    4460  979.28  4528.3  978.37
  4571.5  976.12  4670.3  970.05  4713.3  964.94  4756.6  962.13  4795.9  961.74
  4864.5  959.48  4956.1  959.86  4970.4  958.17  4984.7  954.51  5009.3  953.46
  5009.8  952.96  5017.3  953.46    5042   953.9  5084.9  959.33  5105.7   958.6
  5143.6  959.47  5183.8  961.63  5198.1   961.1  5226.7  963.82  5247.5  967.84
  5255.3  968.26  5268.7  970.74  5296.9  977.64  5333.3  982.32    5347  983.24
#Mann= 9 ,-1 , 0
  4388.5     .05       0  4410.6     .12       0  4571.5     .05       0
  4713.3     .12       0  4756.6     .05       0  4864.5     .12       0
  5009.3     .07       0  5017.3     .12       0  5143.6     .05       0
Bank Sta=5009.3,5017.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,5140    ,378,378,378
BEGIN DESCRIPTION:
Mapping XS eff0f43c
END DESCRIPTION:
XS GIS Cut Line= 3
      2868339.96     10175653.66      2868007.02     10175277.21
      2867475.46     10175069.13
#Sta/Elev= 30
  4226.8  982.91  4407.3  974.94  4521.1  966.98  4584.6  964.04  4611.5  961.75
  4676.7  958.27  4683.3  958.74  4785.8  956.85  4894.4   957.4  4943.3  955.84
    4967   955.8  4978.5   955.4  4988.5  953.24    5006  951.77  5006.5  951.27
  5013.6  951.27  5014.1  951.77  5027.4  953.45  5042.2  952.74  5051.8  954.11
  5055.7  953.97  5081.7  955.28  5117.4  955.14  5160.3  956.12  5171.1  958.28
    5220  963.11  5225.4  964.96  5244.5  967.07  5274.3  972.95  5300.2  976.07
#Mann= 5 ,-1 , 0
  4226.8     .05       0  4611.5     .12       0    5006     .07       0
  5014.1     .12       0  5055.7     .05       0
Bank Sta=5006,5014.1
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4762    ,287,287,287
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 10.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868338.03     10175042.65      2867946.49     10174811.89
       2867448.9     10174832.62
#Sta/Elev= 30
    4418  965.64  4448.2  962.74  4463.8  960.11  4528.2  954.76  4639.5  951.18
  4703.9  949.88  4719.5  950.45  4762.5  949.83    4821  951.88  4850.2  954.04
  4953.4  954.12  4963.4  953.59  4973.4  948.52  4993.4  943.27  4999.4  943.01
  4999.9  942.51  5007.5  943.01  5013.4  944.76  5020.1  948.23  5043.4  950.69
  5053.4  948.43  5063.5  944.95  5083.5  944.96    5093   946.6  5113.5  951.49
  5153.5  956.28  5173.5  957.45  5203.6  963.78  5293.7  972.42  5370.5  976.72
#Mann= 4 ,-1 , 0
    4418     .12       0  4999.4     .07       0  5007.5     .12       0
    5093     .05       0
Bank Sta=4999.4,5007.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,4475    ,658,658,658
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 9.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868555.65     10174503.11      2867889.74     10174530.05
      2867566.32     10174533.84
#Sta/Elev= 30
  4252.1  976.13  4288.6  973.74  4342.1  968.69  4371.5  964.03  4376.5  964.45
  4382.2  962.91  4392.2  962.44  4412.2  957.97  4452.2  953.01  4522.3   948.1
  4562.3  943.05  4602.4  945.05  4612.4  944.64  4625.3  946.97  4722.4  946.02
  4742.5  946.82  4762.5  949.16  4882.6  948.98  4970.9  946.69  4998.6   940.9
  4999.1   940.4  5006.7   940.9  5032.6  942.29  5052.6   941.9  5069.7  944.98
  5082.6  947.99  5122.6  954.25  5152.6  957.54  5202.6  960.63    5242  961.26
#Mann= 6 ,-1 , 0
  4252.1     .12       0  4288.6     .05       0  4970.9     .12       0
  4998.6     .07       0  5006.7     .12       0  5069.7     .05       0
Bank Sta=4998.6,5006.7
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3817    ,509,509,509
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 8.0
END DESCRIPTION:
XS GIS Cut Line= 3
       2868506.4      10174049.6      2868088.36     10174055.28
      2867490.63     10174074.19
#Sta/Elev= 30
  4675.9  965.05    4732  961.86  4906.6  951.52  4916.6  950.42  4936.6  946.14
  4966.6  941.76  4996.6  935.79  5012.3  934.86  5012.8  934.36  5020.4  934.36
  5020.9  934.86  5026.6  937.23  5066.6  942.09    5119  943.25  5156.7  945.06
  5182.6  947.63  5236.7  951.38  5286.7  951.88  5326.8  950.32  5386.8  946.65
  5406.8  944.94  5416.8  943.03  5426.8  939.89  5436.8  940.13  5446.8  942.42
  5466.8  944.49  5526.9  946.81  5586.9  951.07  5636.9  955.81    5692  958.93
#Mann= 5 ,-1 , 0
  4675.9     .05       0    4732     .12       0  5012.3     .07       0
  5020.9     .12       0    5119     .05       0
Bank Sta=5012.3,5020.9
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,3308    ,460,460,460
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 7.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868642.62     10173675.09      2868186.68     10173579.19
      2867740.54     10173572.94
#Sta/Elev= 30
  4397.2  962.23  4430.5  962.16  4445.2   960.7  4496.3  958.65  4700.6  944.62
  4775.6  941.99    4819  939.82  4843.7  939.37  4874.1  936.87  4894.1  936.93
  4924.1   935.7  4934.1  934.74  4939.7     933  4944.7  933.28  4964.1  927.58
  4969.7  927.31  4970.2  926.81  4978.1  926.81  4978.6  927.31  4984.1  927.98
  4994.1  927.89  5014.1  931.66  5044.1  936.12  5072.7  938.99  5084.1  940.37
  5124.1   947.1  5164.1   948.9  5224.1   950.3  5274.2     953  5309.3  955.62
#Mann= 5 ,-1 , 0
  4397.2     .05       0  4775.6     .12       0  4969.7     .07       0
  4978.6     .12       0  5072.7     .05       0
Bank Sta=4969.7,4978.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2848    ,310,310,310
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 6.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868695.53     10172920.36      2868216.98     10173118.97
      2867739.54      10173334.1
#Sta/Elev= 30
  4399.8  948.72  4471.1  941.75  4529.7  938.47    4572  938.57  4616.6  936.97
  4654.4  935.95  4670.3  937.41  4760.8  933.96  4808.5  934.41  4854.4  933.11
  4952.3  934.22  4966.6  932.22  4984.3   923.2  4989.8   922.8  4990.3   922.3
  5002.5   922.8  5012.9  925.47    5029  927.24  5041.5  930.93  5066.8  932.49
  5094.8  933.74  5139.6  933.84  5162.7  935.28  5193.6  940.38  5237.6   943.5
  5248.4  943.19  5283.9  945.64  5330.2   946.3  5393.1  950.69  5441.6  954.16
#Mann= 6 ,-1 , 0
  4399.8     .05       0  4616.6     .12       0  4989.8     .07       0
  5002.5     .12       0  5066.8     .05       0  5393.1     .12       0
Bank Sta=4989.8,5002.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2538    ,381,381,381
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 5.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868580.14     10172560.97      2868071.33     10172844.69
      2867699.72     10173020.12
#Sta/Elev= 30
  4330.9  955.19  4489.9  946.29  4505.9  943.77  4511.6  944.62  4527.6  941.52
  4652.2  933.77  4657.9  932.06  4695.6  933.12  4733.3   930.6  4798.5  931.97
  4828.3   931.3  4836.2  929.38  4863.6  932.05  4917.8  931.03  4946.1  929.36
  4952.9  926.09  4968.9  923.51  5001.8  922.37  5002.3  921.87  5014.5  922.37
    5020  927.47  5037.2   931.3  5071.8  934.78    5104   938.6  5193.5  947.61
  5218.3  951.43  5224.9  954.01  5230.4  953.15  5253.2  955.29  5324.4  963.54
#Mann= 6 ,-1 , 0
  4330.9     .12       0  5001.8     .07       0  5014.5     .12       0
  5071.8     .05       0    5104     .12       0  5193.5     .05       0
Bank Sta=5001.8,5014.5
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,2157    ,601,601,601
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 4.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2868216.98      10172305.6      2867884.07     10172595.01
      2867729.83     10172820.73
#Sta/Elev= 30
  4683.7  964.05  4711.6  959.65  4742.6  952.57  4767.6  948.49  4775.3  948.43
  4824.6  940.01  4853.5  936.51  4938.8  927.46  4980.3  922.09  4981.6  919.92
  4982.1  919.42  4994.4  919.92  5002.2  921.64  5008.8   920.4  5016.5  921.21
  5029.9  924.31  5051.6  927.07  5094.3  929.66  5165.6  937.64  5186.6  938.59
  5201.5  940.47  5207.5  939.94  5237.4  941.16  5252.3  943.08  5294.2  944.51
  5303.1  946.26  5309.2  945.42  5324.1  947.38    5345  947.58  5398.2  951.41
#Mann= 6 ,-1 , 0
  4683.7     .12       0  4742.6     .05       0  4853.5     .12       0
  4938.8     .05       0  4981.6     .03       0  4994.4     .05       0
Bank Sta=4981.6,4994.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1556    ,185,185,185
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 3.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867710.03     10172141.04      2867577.64     10172156.17
      2867337.42     10172545.83
#Sta/Elev= 30
  4671.8  945.05  4696.3  944.16  4766.8   939.4  4776.8  937.89    4797  936.92
  4803.5  935.62  4812.8  935.06  4818.7  933.38  4834.1  932.24    4840  930.44
  4855.4  929.91  4861.2  928.63  4897.9  925.84  4913.3  925.81  4919.2   924.8
  4942.4  923.84  4955.9  921.36  4965.4  918.57  4977.7  913.26  4992.5  912.67
  5001.5  911.48    5002  910.98  5014.3  911.48  5023.3  915.59  5029.2  915.91
  5033.5  917.59  5065.9  930.07  5081.3  932.24  5087.2  932.01  5262.8  940.28
#Mann= 4 ,-1 , 0
  4671.8     .12       0  5001.5     .07       0  5014.3     .12       0
  5033.5     .05       0
Bank Sta=5001.5,5014.3
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1371    ,309,309,309
BEGIN DESCRIPTION:
Mapping XS 64cedae0
END DESCRIPTION:
XS GIS Cut Line= 2
      2867681.76     10172111.39      2867065.14     10172327.83
#Sta/Elev= 30
    4613  943.56    4660  939.78  4672.4  939.88    4691  937.27  4714.8  937.27
    4722  935.33  4727.3  935.62    4753  930.52  4778.4  928.11  4809.7  927.52
    4815  926.53  4820.8  927.38  4852.6  924.84    4895  923.67    4908  922.01
  4916.2  922.81  4940.3  921.37 4969.26  917.63    5001  908.98  5005.2  908.71
  5005.7  908.21    5018  908.71 5030.95  917.38 5040.29  919.74  5083.3  925.83
  5114.3  928.28  5119.6  927.87  5145.3  930.79    5233  936.09  5266.5  935.41
#Mann= 4 ,-1 , 0
    4613     .12       0  4940.3     .05       0  5005.2     .07       0
    5018     .05       0
Bank Sta=5005.2,5018
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,1062    ,277,277,277
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 2.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867705.64     10172053.11      2867555.27     10172058.76
      2867305.66     10171853.09
#Sta/Elev= 30
  4718.4  942.41  4778.4  935.67  4798.4  935.09  4818.4   933.3  4847.5  929.21
  4852.5  929.96  4868.9  928.77  4872.4  927.57  4880.2  927.42    4901  925.24
  4907.5  925.75  4921.9  923.26  4936.2  922.68  4944.1  921.13  4954.4  920.41
 4961.66  918.34  4971.5  917.26    5000  911.04  5000.3  909.36  5000.8  908.86
  5015.6  909.36 5026.42  917.16 5042.49  921.99  5049.7  923.08  5070.5  930.83
  5092.6  936.22  5106.9   941.1  5127.7   945.9  5156.4  948.49  5192.3  948.49
#Mann= 4 ,-1 , 0
  4718.4     .12       0  5000.3     .07       0  5015.6     .12       0
  5070.5     .05       0
Bank Sta=5000.3,5015.6
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Type RM Length L Ch R = 1 ,785     ,0,0,0
BEGIN DESCRIPTION:
COTTONWOOD CREEK 01 1.0
END DESCRIPTION:
XS GIS Cut Line= 3
      2867919.93     10172008.64      2867533.81     10171681.68
      2867205.64      10171603.1
#Sta/Elev= 30
  4647.3  936.47  4711.1  933.14  4724.2  933.38  4768.1  932.77  4796.7  930.39
  4817.5  930.76  4864.4  928.22  4930.6   925.1  4952.6  919.98  4966.9  914.84
  4973.5  910.17  4980.1   907.8  4980.6   907.3  4995.4   907.8  5016.4  910.58
  5044.9  924.31  5051.5  926.15  5113.3  928.58  5143.8  930.03  5167.7  934.84
  5172.8   932.8  5192.5   935.1  5209.7  935.45  5214.8   934.2  5251.7  936.44
  5274.7  935.13  5293.8  936.92  5298.9  935.23  5367.8  941.01  5490.7  947.79
#Mann= 8 ,-1 , 0
  4647.3     .05       0  4711.1     .12       0  4724.2     .05       0
  4864.4     .12       0  4980.1     .07       0  4995.4     .12       0
  5113.3     .05       0  5367.8     .12       0
Bank Sta=4980.1,4995.4
XS Rating Curve= 0 ,0
Exp/Cntr=0.3,0.1

Chan Stop Cuts=-1
Use User Specified Reach Order=0
Composite Channel Slope=5
